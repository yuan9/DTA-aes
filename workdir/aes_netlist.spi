$ Spice netlist generated by v2lvs
$ v2019.2_26.18    Tue May 7 10:56:43 PDT 2019
.INCLUDE "/opt/libraries/TSMCHOME/digital/Back_End/spice/tcb018gbwp7t_270a/tcb018gbwp7t_270a.spi"
*.BUSDELIMITER [

.SUBCKT aes_rcon clk kld out[31] out[30] out[29] out[28] out[27] out[26]
+ out[25] out[24] out[23] out[22] out[21] out[20] out[19] out[18] out[17]
+ out[16] out[15] out[14] out[13] out[12] out[11] out[10] out[9] out[8] out[7]
+ out[6] out[5] out[4] out[3] out[2] out[1] out[0]
*.CONNECT out[0] out[23]
*.CONNECT out[1] out[23]
*.CONNECT out[2] out[23]
*.CONNECT out[3] out[23]
*.CONNECT out[4] out[23]
*.CONNECT out[5] out[23]
*.CONNECT out[6] out[23]
*.CONNECT out[7] out[23]
*.CONNECT out[8] out[23]
*.CONNECT out[9] out[23]
*.CONNECT out[10] out[23]
*.CONNECT out[11] out[23]
*.CONNECT out[12] out[23]
*.CONNECT out[13] out[23]
*.CONNECT out[14] out[23]
*.CONNECT out[15] out[23]
*.CONNECT out[16] out[23]
*.CONNECT out[17] out[23]
*.CONNECT out[18] out[23]
*.CONNECT out[19] out[23]
*.CONNECT out[20] out[23]
*.CONNECT out[21] out[23]
*.CONNECT out[22] out[23]
Xrcnt_reg[0] DFQD0BWP7T $PINS D=N78 CP=clk Q=rcnt[0]
Xrcnt_reg[1] DFKCNQD1BWP7T $PINS CN=n5 D=n4 CP=clk Q=rcnt[1]
Xrcnt_reg[2] DFKCNQD1BWP7T $PINS CN=n5 D=n1 CP=clk Q=rcnt[2]
Xout_reg[24] DFQD0BWP7T $PINS D=N70 CP=clk Q=out[24]
Xrcnt_reg[3] DFQD0BWP7T $PINS D=N81 CP=clk Q=rcnt[3]
Xout_reg[25] DFQD0BWP7T $PINS D=N71 CP=clk Q=out[25]
Xout_reg[31] DFQD0BWP7T $PINS D=N77 CP=clk Q=out[31]
Xout_reg[30] DFQD0BWP7T $PINS D=N76 CP=clk Q=out[30]
Xout_reg[29] DFQD0BWP7T $PINS D=N75 CP=clk Q=out[29]
Xout_reg[28] DFQD0BWP7T $PINS D=N74 CP=clk Q=out[28]
Xout_reg[27] DFQD0BWP7T $PINS D=N73 CP=clk Q=out[27]
Xout_reg[26] DFQD0BWP7T $PINS D=N72 CP=clk Q=out[26]
XU3 TIELBWP7T $PINS ZN=out[23]
XU4 INVD1BWP7T $PINS I=n3 ZN=n5
XU5 CKBD1BWP7T $PINS I=kld Z=n3
XU6 CKND0BWP7T $PINS I=n6 ZN=n1
XU7 OAI21D0BWP7T $PINS A1=N70 A2=n7 B=n8 ZN=N81
XU8 NR3D0BWP7T $PINS A1=n9 A2=rcnt[0] A3=n10 ZN=N77
XU9 NR3D0BWP7T $PINS A1=n9 A2=n11 A3=n10 ZN=N76
XU10 OAI31D0BWP7T $PINS A1=n9 A2=rcnt[0] A3=n4 B=n12 ZN=N75
XU11 CKND0BWP7T $PINS I=n13 ZN=n9
XU12 OAI31D0BWP7T $PINS A1=n11 A2=n4 A3=n14 B=n12 ZN=N74
XU13 AOI31D0BWP7T $PINS A1=n6 A2=n5 A3=n15 B=n13 ZN=n14
XU14 NR3D0BWP7T $PINS A1=n6 A2=n3 A3=n15 ZN=n13
XU15 CKND0BWP7T $PINS I=rcnt[0] ZN=n11
XU16 MUX2ND0BWP7T $PINS I0=n16 I1=n17 S=n4 ZN=N73
XU17 IND3D0BWP7T $PINS A1=n15 B1=n6 B2=N78 ZN=n17
XU18 IND2D0BWP7T $PINS A1=n18 B1=n15 ZN=n16
XU19 OAI31D0BWP7T $PINS A1=n18 A2=n10 A3=n15 B=n12 ZN=N72
XU20 ND4D0BWP7T $PINS A1=N78 A2=n15 A3=n6 A4=n10 ZN=n12
XU21 NR2D0BWP7T $PINS A1=n3 A2=rcnt[0] ZN=N78
XU22 XNR2D1BWP7T $PINS A1=n19 A2=n7 ZN=n15
XU23 NR2D0BWP7T $PINS A1=n20 A2=n21 ZN=n19
XU24 ND3D0BWP7T $PINS A1=n6 A2=n5 A3=rcnt[0] ZN=n18
XU25 CKXOR2D0BWP7T $PINS A1=rcnt[2] A2=n21 Z=n6
XU26 OAI31D0BWP7T $PINS A1=n22 A2=n3 A3=n23 B=n8 ZN=N71
XU27 ND4D0BWP7T $PINS A1=n23 A2=n22 A3=n5 A4=n7 ZN=n8
XU28 CKND0BWP7T $PINS I=rcnt[3] ZN=n7
XU29 AO21D0BWP7T $PINS A1=n22 A2=n23 B=n3 Z=N70
XU30 CKXOR2D0BWP7T $PINS A1=rcnt[2] A2=n4 Z=n23
XU31 CKND0BWP7T $PINS I=n10 ZN=n4
XU32 OAI21D0BWP7T $PINS A1=n20 A2=n10 B=n21 ZN=n22
XU33 OAI21D0BWP7T $PINS A1=rcnt[1] A2=rcnt[0] B=n21 ZN=n10
XU34 CKND2D0BWP7T $PINS A1=rcnt[1] A2=rcnt[0] ZN=n21
XU35 CKND0BWP7T $PINS I=rcnt[2] ZN=n20
.ENDS

.SUBCKT aes_sbox_1 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_2 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_3 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_4 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_key_expand_128 krst clk kld key[127] key[126] key[125] key[124]
+ key[123] key[122] key[121] key[120] key[119] key[118] key[117] key[116]
+ key[115] key[114] key[113] key[112] key[111] key[110] key[109] key[108]
+ key[107] key[106] key[105] key[104] key[103] key[102] key[101] key[100]
+ key[99] key[98] key[97] key[96] key[95] key[94] key[93] key[92] key[91]
+ key[90] key[89] key[88] key[87] key[86] key[85] key[84] key[83] key[82]
+ key[81] key[80] key[79] key[78] key[77] key[76] key[75] key[74] key[73]
+ key[72] key[71] key[70] key[69] key[68] key[67] key[66] key[65] key[64]
+ key[63] key[62] key[61] key[60] key[59] key[58] key[57] key[56] key[55]
+ key[54] key[53] key[52] key[51] key[50] key[49] key[48] key[47] key[46]
+ key[45] key[44] key[43] key[42] key[41] key[40] key[39] key[38] key[37]
+ key[36] key[35] key[34] key[33] key[32] key[31] key[30] key[29] key[28]
+ key[27] key[26] key[25] key[24] key[23] key[22] key[21] key[20] key[19]
+ key[18] key[17] key[16] key[15] key[14] key[13] key[12] key[11] key[10]
+ key[9] key[8] key[7] key[6] key[5] key[4] key[3] key[2] key[1] key[0]
+ wo_0[31] wo_0[30] wo_0[29] wo_0[28] wo_0[27] wo_0[26] wo_0[25] wo_0[24]
+ wo_0[23] wo_0[22] wo_0[21] wo_0[20] wo_0[19] wo_0[18] wo_0[17] wo_0[16]
+ wo_0[15] wo_0[14] wo_0[13] wo_0[12] wo_0[11] wo_0[10] wo_0[9] wo_0[8] wo_0[7]
+ wo_0[6] wo_0[5] wo_0[4] wo_0[3] wo_0[2] wo_0[1] wo_0[0] wo_1[31] wo_1[30]
+ wo_1[29] wo_1[28] wo_1[27] wo_1[26] wo_1[25] wo_1[24] wo_1[23] wo_1[22]
+ wo_1[21] wo_1[20] wo_1[19] wo_1[18] wo_1[17] wo_1[16] wo_1[15] wo_1[14]
+ wo_1[13] wo_1[12] wo_1[11] wo_1[10] wo_1[9] wo_1[8] wo_1[7] wo_1[6] wo_1[5]
+ wo_1[4] wo_1[3] wo_1[2] wo_1[1] wo_1[0] wo_2[31] wo_2[30] wo_2[29] wo_2[28]
+ wo_2[27] wo_2[26] wo_2[25] wo_2[24] wo_2[23] wo_2[22] wo_2[21] wo_2[20]
+ wo_2[19] wo_2[18] wo_2[17] wo_2[16] wo_2[15] wo_2[14] wo_2[13] wo_2[12]
+ wo_2[11] wo_2[10] wo_2[9] wo_2[8] wo_2[7] wo_2[6] wo_2[5] wo_2[4] wo_2[3]
+ wo_2[2] wo_2[1] wo_2[0] wo_3[31] wo_3[30] wo_3[29] wo_3[28] wo_3[27] wo_3[26]
+ wo_3[25] wo_3[24] wo_3[23] wo_3[22] wo_3[21] wo_3[20] wo_3[19] wo_3[18]
+ wo_3[17] wo_3[16] wo_3[15] wo_3[14] wo_3[13] wo_3[12] wo_3[11] wo_3[10]
+ wo_3[9] wo_3[8] wo_3[7] wo_3[6] wo_3[5] wo_3[4] wo_3[3] wo_3[2] wo_3[1]
+ wo_3[0]
Xu0 aes_sbox_4 $PINS a[7]=wo_3[23] a[6]=wo_3[22] a[5]=wo_3[21] a[4]=wo_3[20]
+ a[3]=wo_3[19] a[2]=wo_3[18] a[1]=wo_3[17] a[0]=wo_3[16] d[7]=subword[31]
+ d[6]=subword[30] d[5]=subword[29] d[4]=subword[28] d[3]=subword[27]
+ d[2]=subword[26] d[1]=subword[25] d[0]=subword[24]
Xu1 aes_sbox_3 $PINS a[7]=wo_3[15] a[6]=wo_3[14] a[5]=wo_3[13] a[4]=wo_3[12]
+ a[3]=wo_3[11] a[2]=wo_3[10] a[1]=wo_3[9] a[0]=wo_3[8] d[7]=subword[23]
+ d[6]=subword[22] d[5]=subword[21] d[4]=subword[20] d[3]=subword[19]
+ d[2]=subword[18] d[1]=subword[17] d[0]=subword[16]
Xu2 aes_sbox_2 $PINS a[7]=wo_3[7] a[6]=wo_3[6] a[5]=wo_3[5] a[4]=wo_3[4]
+ a[3]=wo_3[3] a[2]=wo_3[2] a[1]=wo_3[1] a[0]=wo_3[0] d[7]=subword[15]
+ d[6]=subword[14] d[5]=subword[13] d[4]=subword[12] d[3]=subword[11]
+ d[2]=subword[10] d[1]=subword[9] d[0]=subword[8]
Xu3 aes_sbox_1 $PINS a[7]=wo_3[31] a[6]=wo_3[30] a[5]=wo_3[29] a[4]=wo_3[28]
+ a[3]=wo_3[27] a[2]=wo_3[26] a[1]=wo_3[25] a[0]=wo_3[24] d[7]=subword[7]
+ d[6]=subword[6] d[5]=subword[5] d[4]=subword[4] d[3]=subword[3] d[2]=subword[2]
+ d[1]=subword[1] d[0]=subword[0]
Xr0 aes_rcon $PINS clk=n24 kld=n1 out[31]=rcon[31] out[30]=rcon[30]
+ out[29]=rcon[29] out[28]=rcon[28] out[27]=rcon[27] out[26]=rcon[26]
+ out[25]=rcon[25] out[24]=rcon[24] out[23]=rcon[23] out[22]=rcon[22]
+ out[21]=rcon[21] out[20]=rcon[20] out[19]=rcon[19] out[18]=rcon[18]
+ out[17]=rcon[17] out[16]=rcon[16] out[15]=rcon[15] out[14]=rcon[14]
+ out[13]=rcon[13] out[12]=rcon[12] out[11]=rcon[11] out[10]=rcon[10]
+ out[9]=rcon[9] out[8]=rcon[8] out[7]=rcon[7] out[6]=rcon[6] out[5]=rcon[5]
+ out[4]=rcon[4] out[3]=rcon[3] out[2]=rcon[2] out[1]=rcon[1] out[0]=rcon[0]
Xw_reg[0][30] DFCNQD1BWP7T $PINS D=N73 CP=n24 CDN=n10 Q=wo_0[30]
Xw_reg[0][19] DFCNQD1BWP7T $PINS D=N62 CP=n24 CDN=n10 Q=wo_0[19]
Xw_reg[0][20] DFCNQD1BWP7T $PINS D=N63 CP=n24 CDN=n9 Q=wo_0[20]
Xw_reg[0][4] DFCNQD1BWP7T $PINS D=N47 CP=n24 CDN=n9 Q=wo_0[4]
Xw_reg[0][17] DFCNQD1BWP7T $PINS D=N60 CP=n25 CDN=n10 Q=wo_0[17]
Xw_reg[0][1] DFCNQD1BWP7T $PINS D=N44 CP=n25 CDN=n10 Q=wo_0[1]
Xw_reg[0][3] DFCNQD1BWP7T $PINS D=N46 CP=n25 CDN=n10 Q=wo_0[3]
Xw_reg[0][27] DFCNQD1BWP7T $PINS D=N70 CP=n24 CDN=n10 Q=wo_0[27]
Xw_reg[0][28] DFCNQD1BWP7T $PINS D=N71 CP=n24 CDN=n9 Q=wo_0[28]
Xw_reg[0][25] DFCNQD1BWP7T $PINS D=N68 CP=n25 CDN=n10 Q=wo_0[25]
Xw_reg[0][29] DFCNQD1BWP7T $PINS D=N72 CP=n24 CDN=n9 Q=wo_0[29]
Xw_reg[0][31] DFCNQD1BWP7T $PINS D=N74 CP=n24 CDN=n9 Q=wo_0[31]
Xw_reg[0][24] DFCNQD1BWP7T $PINS D=N67 CP=n25 CDN=n11 Q=wo_0[24]
Xw_reg[0][26] DFCNQD1BWP7T $PINS D=N69 CP=n25 CDN=n11 Q=wo_0[26]
Xw_reg[2][17] DFCNQD1BWP7T $PINS D=N192 CP=n27 CDN=n13 Q=wo_2[17]
Xw_reg[1][17] DFCNQD1BWP7T $PINS D=N126 CP=n27 CDN=n14 Q=wo_1[17]
Xw_reg[2][19] DFCNQD1BWP7T $PINS D=N194 CP=n28 CDN=n15 Q=wo_2[19]
Xw_reg[1][19] DFCNQD1BWP7T $PINS D=N128 CP=n28 CDN=n16 Q=wo_1[19]
Xw_reg[2][20] DFCNQD1BWP7T $PINS D=N195 CP=n29 CDN=n17 Q=wo_2[20]
Xw_reg[1][20] DFCNQD1BWP7T $PINS D=N129 CP=n29 CDN=n18 Q=wo_1[20]
Xw_reg[2][1] DFCNQD1BWP7T $PINS D=N176 CP=n26 CDN=n13 Q=wo_2[1]
Xw_reg[1][1] DFCNQD1BWP7T $PINS D=N110 CP=n26 CDN=n13 Q=wo_1[1]
Xw_reg[2][3] DFCNQD1BWP7T $PINS D=N178 CP=n27 CDN=n14 Q=wo_2[3]
Xw_reg[1][3] DFCNQD1BWP7T $PINS D=N112 CP=n27 CDN=n14 Q=wo_1[3]
Xw_reg[2][4] DFCNQD1BWP7T $PINS D=N179 CP=n29 CDN=n17 Q=wo_2[4]
Xw_reg[1][4] DFCNQD1BWP7T $PINS D=N113 CP=n29 CDN=n17 Q=wo_1[4]
Xw_reg[0][11] DFCNQD1BWP7T $PINS D=N54 CP=n24 CDN=n9 Q=wo_0[11]
Xw_reg[0][12] DFCNQD1BWP7T $PINS D=N55 CP=n24 CDN=n9 Q=wo_0[12]
Xw_reg[0][9] DFCNQD1BWP7T $PINS D=N52 CP=n25 CDN=n11 Q=wo_0[9]
Xw_reg[0][13] DFCNQD1BWP7T $PINS D=N56 CP=n24 CDN=n10 Q=wo_0[13]
Xw_reg[0][14] DFCNQD1BWP7T $PINS D=N57 CP=n24 CDN=n10 Q=wo_0[14]
Xw_reg[0][15] DFCNQD1BWP7T $PINS D=N58 CP=n24 CDN=n9 Q=wo_0[15]
Xw_reg[0][8] DFCNQD1BWP7T $PINS D=N51 CP=n25 CDN=n11 Q=wo_0[8]
Xw_reg[0][10] DFCNQD1BWP7T $PINS D=N53 CP=n25 CDN=n10 Q=wo_0[10]
Xw_reg[0][16] DFCNQD1BWP7T $PINS D=N59 CP=n25 CDN=n11 Q=wo_0[16]
Xw_reg[0][0] DFCNQD1BWP7T $PINS D=N43 CP=n30 CDN=n19 Q=wo_0[0]
Xw_reg[2][30] DFCNQD1BWP7T $PINS D=N205 CP=n28 CDN=n15 Q=wo_2[30]
Xw_reg[1][30] DFCNQD1BWP7T $PINS D=N139 CP=n28 CDN=n15 Q=wo_1[30]
Xw_reg[0][21] DFCNQD1BWP7T $PINS D=N64 CP=n24 CDN=n10 Q=wo_0[21]
Xw_reg[0][22] DFCNQD1BWP7T $PINS D=N65 CP=n24 CDN=n9 Q=wo_0[22]
Xw_reg[0][23] DFCNQD1BWP7T $PINS D=N66 CP=n24 CDN=n9 Q=wo_0[23]
Xw_reg[0][5] DFCNQD1BWP7T $PINS D=N48 CP=n24 CDN=n10 Q=wo_0[5]
Xw_reg[0][6] DFCNQD1BWP7T $PINS D=N49 CP=n24 CDN=n9 Q=wo_0[6]
Xw_reg[0][7] DFCNQD1BWP7T $PINS D=N50 CP=n24 CDN=n9 Q=wo_0[7]
Xw_reg[0][18] DFCNQD1BWP7T $PINS D=N61 CP=n25 CDN=n11 Q=wo_0[18]
Xw_reg[0][2] DFCNQD1BWP7T $PINS D=N45 CP=n25 CDN=n11 Q=wo_0[2]
Xw_reg[2][9] DFCNQD1BWP7T $PINS D=N184 CP=n26 CDN=n13 Q=wo_2[9]
Xw_reg[1][9] DFCNQD1BWP7T $PINS D=N118 CP=n26 CDN=n13 Q=wo_1[9]
Xw_reg[2][11] DFCNQD1BWP7T $PINS D=N186 CP=n28 CDN=n17 Q=wo_2[11]
Xw_reg[1][11] DFCNQD1BWP7T $PINS D=N120 CP=n29 CDN=n17 Q=wo_1[11]
Xw_reg[2][12] DFCNQD1BWP7T $PINS D=N187 CP=n29 CDN=n18 Q=wo_2[12]
Xw_reg[1][12] DFCNQD1BWP7T $PINS D=N121 CP=n29 CDN=n18 Q=wo_1[12]
Xw_reg[2][25] DFCNQD1BWP7T $PINS D=N200 CP=n26 CDN=n13 Q=wo_2[25]
Xw_reg[1][25] DFCNQD1BWP7T $PINS D=N134 CP=n26 CDN=n13 Q=wo_1[25]
Xw_reg[2][27] DFCNQD1BWP7T $PINS D=N202 CP=n27 CDN=n14 Q=wo_2[27]
Xw_reg[1][27] DFCNQD1BWP7T $PINS D=N136 CP=n27 CDN=n14 Q=wo_1[27]
Xw_reg[2][28] DFCNQD1BWP7T $PINS D=N203 CP=n29 CDN=n17 Q=wo_2[28]
Xw_reg[1][28] DFCNQD1BWP7T $PINS D=N137 CP=n29 CDN=n17 Q=wo_1[28]
Xw_reg[2][8] DFCNQD1BWP7T $PINS D=N183 CP=n25 CDN=n12 Q=wo_2[8]
Xw_reg[1][8] DFCNQD1BWP7T $PINS D=N117 CP=n26 CDN=n12 Q=wo_1[8]
Xw_reg[2][10] DFCNQD1BWP7T $PINS D=N185 CP=n27 CDN=n14 Q=wo_2[10]
Xw_reg[1][10] DFCNQD1BWP7T $PINS D=N119 CP=n27 CDN=n14 Q=wo_1[10]
Xw_reg[2][13] DFCNQD1BWP7T $PINS D=N188 CP=n28 CDN=n16 Q=wo_2[13]
Xw_reg[1][13] DFCNQD1BWP7T $PINS D=N122 CP=n28 CDN=n16 Q=wo_1[13]
Xw_reg[2][14] DFCNQD1BWP7T $PINS D=N189 CP=n27 CDN=n15 Q=wo_2[14]
Xw_reg[1][14] DFCNQD1BWP7T $PINS D=N123 CP=n27 CDN=n15 Q=wo_1[14]
Xw_reg[2][16] DFCNQD1BWP7T $PINS D=N191 CP=n25 CDN=n11 Q=wo_2[16]
Xw_reg[1][16] DFCNQD1BWP7T $PINS D=N125 CP=n25 CDN=n12 Q=wo_1[16]
Xw_reg[2][24] DFCNQD1BWP7T $PINS D=N199 CP=n26 CDN=n12 Q=wo_2[24]
Xw_reg[1][24] DFCNQD1BWP7T $PINS D=N133 CP=n26 CDN=n12 Q=wo_1[24]
Xw_reg[2][26] DFCNQD1BWP7T $PINS D=N201 CP=n25 CDN=n11 Q=wo_2[26]
Xw_reg[1][26] DFCNQD1BWP7T $PINS D=N135 CP=n25 CDN=n11 Q=wo_1[26]
Xw_reg[2][29] DFCNQD1BWP7T $PINS D=N204 CP=n28 CDN=n16 Q=wo_2[29]
Xw_reg[1][29] DFCNQD1BWP7T $PINS D=N138 CP=n28 CDN=n16 Q=wo_1[29]
Xw_reg[2][31] DFCNQD1BWP7T $PINS D=N206 CP=n29 CDN=n18 Q=wo_2[31]
Xw_reg[1][31] DFCNQD1BWP7T $PINS D=N140 CP=n29 CDN=n18 Q=wo_1[31]
Xw_reg[2][15] DFCNQD1BWP7T $PINS D=N190 CP=n30 CDN=n19 Q=wo_2[15]
Xw_reg[1][15] DFCNQD1BWP7T $PINS D=N124 CP=n30 CDN=n19 Q=wo_1[15]
Xw_reg[2][0] DFCNQD1BWP7T $PINS D=N175 CP=n30 CDN=n19 Q=wo_2[0]
Xw_reg[1][0] DFCNQD1BWP7T $PINS D=N109 CP=n30 CDN=n19 Q=wo_1[0]
Xw_reg[3][17] DFCNQD1BWP7T $PINS D=N258 CP=n26 CDN=n13 Q=wo_3[17]
Xw_reg[3][19] DFCNQD1BWP7T $PINS D=N260 CP=n28 CDN=n15 Q=wo_3[19]
Xw_reg[3][21] DFCNQD1BWP7T $PINS D=N262 CP=n27 CDN=n14 Q=wo_3[21]
Xw_reg[3][23] DFCNQD1BWP7T $PINS D=N264 CP=n29 CDN=n18 Q=wo_3[23]
Xw_reg[3][31] DFCNQD1BWP7T $PINS D=N272 CP=n29 CDN=n18 Q=wo_3[31]
Xw_reg[3][15] DFCNQD1BWP7T $PINS D=N256 CP=n30 CDN=n19 Q=wo_3[15]
Xw_reg[3][8] DFCNQD1BWP7T $PINS D=N249 CP=n25 CDN=n12 Q=wo_3[8]
Xw_reg[3][10] DFCNQD1BWP7T $PINS D=N251 CP=n27 CDN=n14 Q=wo_3[10]
Xw_reg[3][14] DFCNQD1BWP7T $PINS D=N255 CP=n27 CDN=n15 Q=wo_3[14]
Xw_reg[3][18] DFCNQD1BWP7T $PINS D=N259 CP=n26 CDN=n12 Q=wo_3[18]
Xw_reg[3][20] DFCNQD1BWP7T $PINS D=N261 CP=n29 CDN=n17 Q=wo_3[20]
Xw_reg[3][22] DFCNQD1BWP7T $PINS D=N263 CP=n28 CDN=n16 Q=wo_3[22]
Xw_reg[3][24] DFCNQD1BWP7T $PINS D=N265 CP=n26 CDN=n12 Q=wo_3[24]
Xw_reg[2][18] DFCNQD1BWP7T $PINS D=N193 CP=n26 CDN=n12 Q=wo_2[18]
Xw_reg[1][18] DFCNQD1BWP7T $PINS D=N127 CP=n26 CDN=n13 Q=wo_1[18]
Xw_reg[2][21] DFCNQD1BWP7T $PINS D=N196 CP=n27 CDN=n14 Q=wo_2[21]
Xw_reg[1][21] DFCNQD1BWP7T $PINS D=N130 CP=n27 CDN=n15 Q=wo_1[21]
Xw_reg[2][22] DFCNQD1BWP7T $PINS D=N197 CP=n28 CDN=n16 Q=wo_2[22]
Xw_reg[1][22] DFCNQD1BWP7T $PINS D=N131 CP=n28 CDN=n17 Q=wo_1[22]
Xw_reg[2][2] DFCNQD1BWP7T $PINS D=N177 CP=n26 CDN=n12 Q=wo_2[2]
Xw_reg[1][2] DFCNQD1BWP7T $PINS D=N111 CP=n26 CDN=n12 Q=wo_1[2]
Xw_reg[2][5] DFCNQD1BWP7T $PINS D=N180 CP=n27 CDN=n15 Q=wo_2[5]
Xw_reg[1][5] DFCNQD1BWP7T $PINS D=N114 CP=n27 CDN=n15 Q=wo_1[5]
Xw_reg[2][6] DFCNQD1BWP7T $PINS D=N181 CP=n28 CDN=n16 Q=wo_2[6]
Xw_reg[1][6] DFCNQD1BWP7T $PINS D=N115 CP=n28 CDN=n16 Q=wo_1[6]
Xw_reg[2][7] DFCNQD1BWP7T $PINS D=N182 CP=n29 CDN=n18 Q=wo_2[7]
Xw_reg[1][7] DFCNQD1BWP7T $PINS D=N116 CP=n29 CDN=n18 Q=wo_1[7]
Xw_reg[2][23] DFCNQD1BWP7T $PINS D=N198 CP=n30 CDN=n18 Q=wo_2[23]
Xw_reg[1][23] DFCNQD1BWP7T $PINS D=N132 CP=n30 CDN=n19 Q=wo_1[23]
Xw_reg[3][1] DFCNQD1BWP7T $PINS D=N242 CP=n26 CDN=n13 Q=wo_3[1]
Xw_reg[3][3] DFCNQD1BWP7T $PINS D=N244 CP=n27 CDN=n14 Q=wo_3[3]
Xw_reg[3][4] DFCNQD1BWP7T $PINS D=N245 CP=n29 CDN=n17 Q=wo_3[4]
Xw_reg[3][25] DFCNQD1BWP7T $PINS D=N266 CP=n26 CDN=n13 Q=wo_3[25]
Xw_reg[3][27] DFCNQD1BWP7T $PINS D=N268 CP=n27 CDN=n14 Q=wo_3[27]
Xw_reg[3][29] DFCNQD1BWP7T $PINS D=N270 CP=n28 CDN=n16 Q=wo_3[29]
Xw_reg[3][28] DFCNQD1BWP7T $PINS D=N269 CP=n29 CDN=n17 Q=wo_3[28]
Xw_reg[3][30] DFCNQD1BWP7T $PINS D=N271 CP=n28 CDN=n15 Q=wo_3[30]
Xw_reg[3][9] DFCNQD1BWP7T $PINS D=N250 CP=n26 CDN=n13 Q=wo_3[9]
Xw_reg[3][11] DFCNQD1BWP7T $PINS D=N252 CP=n28 CDN=n17 Q=wo_3[11]
Xw_reg[3][13] DFCNQD1BWP7T $PINS D=N254 CP=n28 CDN=n16 Q=wo_3[13]
Xw_reg[3][12] DFCNQD1BWP7T $PINS D=N253 CP=n29 CDN=n18 Q=wo_3[12]
Xw_reg[3][16] DFCNQD1BWP7T $PINS D=N257 CP=n25 CDN=n11 Q=wo_3[16]
Xw_reg[3][26] DFCNQD1BWP7T $PINS D=N267 CP=n25 CDN=n11 Q=wo_3[26]
Xw_reg[3][0] DFCNQD1BWP7T $PINS D=N241 CP=n30 CDN=n19 Q=wo_3[0]
Xw_reg[3][5] DFCNQD1BWP7T $PINS D=N246 CP=n27 CDN=n15 Q=wo_3[5]
Xw_reg[3][7] DFCNQD1BWP7T $PINS D=N248 CP=n29 CDN=n18 Q=wo_3[7]
Xw_reg[3][2] DFCNQD1BWP7T $PINS D=N243 CP=n26 CDN=n12 Q=wo_3[2]
Xw_reg[3][6] DFCNQD1BWP7T $PINS D=N247 CP=n28 CDN=n16 Q=wo_3[6]
XU3 BUFFD3BWP7T $PINS I=kld Z=n1
XU4 CKBD1BWP7T $PINS I=kld Z=n2
XU5 CKBD1BWP7T $PINS I=n5 Z=n15
XU6 CKBD1BWP7T $PINS I=n5 Z=n16
XU7 CKBD1BWP7T $PINS I=n5 Z=n17
XU8 CKBD1BWP7T $PINS I=n3 Z=n9
XU9 CKBD1BWP7T $PINS I=n4 Z=n14
XU10 CKBD1BWP7T $PINS I=n3 Z=n10
XU11 CKBD1BWP7T $PINS I=n4 Z=n13
XU12 CKBD1BWP7T $PINS I=n4 Z=n12
XU13 CKBD1BWP7T $PINS I=n3 Z=n11
XU14 CKBD1BWP7T $PINS I=n6 Z=n18
XU15 CKBD1BWP7T $PINS I=n6 Z=n19
XU16 CKBD1BWP7T $PINS I=n20 Z=n24
XU17 CKBD1BWP7T $PINS I=n22 Z=n29
XU18 CKBD1BWP7T $PINS I=n22 Z=n28
XU19 CKBD1BWP7T $PINS I=n21 Z=n27
XU20 CKBD1BWP7T $PINS I=n21 Z=n26
XU21 CKBD1BWP7T $PINS I=n20 Z=n25
XU22 CKBD1BWP7T $PINS I=n7 Z=n5
XU23 CKBD1BWP7T $PINS I=n8 Z=n4
XU24 CKBD1BWP7T $PINS I=n8 Z=n3
XU25 CKBD1BWP7T $PINS I=n7 Z=n6
XU26 CKBD1BWP7T $PINS I=n23 Z=n30
XU27 CKBD1BWP7T $PINS I=clk Z=n23
XU28 CKXOR2D1BWP7T $PINS A1=subword[23] A2=wo_0[23] Z=n39
XU29 CKXOR2D1BWP7T $PINS A1=subword[7] A2=wo_0[7] Z=n55
XU30 CKXOR2D1BWP7T $PINS A1=subword[6] A2=wo_0[6] Z=n56
XU31 CKXOR2D1BWP7T $PINS A1=subword[5] A2=wo_0[5] Z=n57
XU32 CKXOR2D1BWP7T $PINS A1=subword[2] A2=wo_0[2] Z=n60
XU33 CKXOR2D1BWP7T $PINS A1=subword[22] A2=wo_0[22] Z=n40
XU34 CKXOR2D1BWP7T $PINS A1=subword[21] A2=wo_0[21] Z=n41
XU35 CKXOR2D1BWP7T $PINS A1=subword[18] A2=wo_0[18] Z=n44
XU36 CKXOR2D1BWP7T $PINS A1=subword[0] A2=wo_0[0] Z=n62
XU37 CKXOR2D1BWP7T $PINS A1=subword[15] A2=wo_0[15] Z=n47
XU38 CKXOR2D1BWP7T $PINS A1=subword[16] A2=wo_0[16] Z=n46
XU39 CKXOR2D1BWP7T $PINS A1=subword[14] A2=wo_0[14] Z=n48
XU40 CKXOR2D1BWP7T $PINS A1=subword[13] A2=wo_0[13] Z=n49
XU41 CKXOR2D1BWP7T $PINS A1=subword[12] A2=wo_0[12] Z=n50
XU42 CKXOR2D1BWP7T $PINS A1=subword[11] A2=wo_0[11] Z=n51
XU43 CKXOR2D1BWP7T $PINS A1=subword[10] A2=wo_0[10] Z=n52
XU44 CKXOR2D1BWP7T $PINS A1=subword[9] A2=wo_0[9] Z=n53
XU45 CKXOR2D1BWP7T $PINS A1=subword[8] A2=wo_0[8] Z=n54
XU46 CKXOR2D1BWP7T $PINS A1=subword[4] A2=wo_0[4] Z=n58
XU47 CKXOR2D1BWP7T $PINS A1=subword[3] A2=wo_0[3] Z=n59
XU48 CKXOR2D1BWP7T $PINS A1=subword[1] A2=wo_0[1] Z=n61
XU49 CKXOR2D1BWP7T $PINS A1=subword[20] A2=wo_0[20] Z=n42
XU50 CKXOR2D1BWP7T $PINS A1=subword[19] A2=wo_0[19] Z=n43
XU51 CKXOR2D1BWP7T $PINS A1=subword[17] A2=wo_0[17] Z=n45
XU52 CKBD1BWP7T $PINS I=krst Z=n8
XU53 CKBD1BWP7T $PINS I=krst Z=n7
XU54 CKBD1BWP7T $PINS I=clk Z=n22
XU55 CKBD1BWP7T $PINS I=clk Z=n21
XU56 CKBD1BWP7T $PINS I=clk Z=n20
XU57 CKMUX2D0BWP7T $PINS I0=n31 I1=key[127] S=n1 Z=N74
XU58 CKMUX2D0BWP7T $PINS I0=n32 I1=key[126] S=n1 Z=N73
XU59 CKMUX2D0BWP7T $PINS I0=n33 I1=key[125] S=n1 Z=N72
XU60 CKMUX2D0BWP7T $PINS I0=n34 I1=key[124] S=n1 Z=N71
XU61 CKMUX2D0BWP7T $PINS I0=n35 I1=key[123] S=n1 Z=N70
XU62 CKMUX2D0BWP7T $PINS I0=n36 I1=key[122] S=n1 Z=N69
XU63 CKMUX2D0BWP7T $PINS I0=n37 I1=key[121] S=n1 Z=N68
XU64 CKMUX2D0BWP7T $PINS I0=n38 I1=key[120] S=n1 Z=N67
XU65 CKMUX2D0BWP7T $PINS I0=n39 I1=key[119] S=n1 Z=N66
XU66 CKMUX2D0BWP7T $PINS I0=n40 I1=key[118] S=n1 Z=N65
XU67 CKMUX2D0BWP7T $PINS I0=n41 I1=key[117] S=n1 Z=N64
XU68 CKMUX2D0BWP7T $PINS I0=n42 I1=key[116] S=n1 Z=N63
XU69 CKMUX2D0BWP7T $PINS I0=n43 I1=key[115] S=n1 Z=N62
XU70 CKMUX2D0BWP7T $PINS I0=n44 I1=key[114] S=n1 Z=N61
XU71 CKMUX2D0BWP7T $PINS I0=n45 I1=key[113] S=n1 Z=N60
XU72 CKMUX2D0BWP7T $PINS I0=n46 I1=key[112] S=n1 Z=N59
XU73 CKMUX2D0BWP7T $PINS I0=n47 I1=key[111] S=n1 Z=N58
XU74 CKMUX2D0BWP7T $PINS I0=n48 I1=key[110] S=n1 Z=N57
XU75 CKMUX2D0BWP7T $PINS I0=n49 I1=key[109] S=n1 Z=N56
XU76 CKMUX2D0BWP7T $PINS I0=n50 I1=key[108] S=n1 Z=N55
XU77 CKMUX2D0BWP7T $PINS I0=n51 I1=key[107] S=n1 Z=N54
XU78 CKMUX2D0BWP7T $PINS I0=n52 I1=key[106] S=n1 Z=N53
XU79 CKMUX2D0BWP7T $PINS I0=n53 I1=key[105] S=n1 Z=N52
XU80 CKMUX2D0BWP7T $PINS I0=n54 I1=key[104] S=n1 Z=N51
XU81 CKMUX2D0BWP7T $PINS I0=n55 I1=key[103] S=n1 Z=N50
XU82 CKMUX2D0BWP7T $PINS I0=n56 I1=key[102] S=n1 Z=N49
XU83 CKMUX2D0BWP7T $PINS I0=n57 I1=key[101] S=n1 Z=N48
XU84 CKMUX2D0BWP7T $PINS I0=n58 I1=key[100] S=n1 Z=N47
XU85 CKMUX2D0BWP7T $PINS I0=n59 I1=key[99] S=n1 Z=N46
XU86 CKMUX2D0BWP7T $PINS I0=n60 I1=key[98] S=n1 Z=N45
XU87 CKMUX2D0BWP7T $PINS I0=n61 I1=key[97] S=n1 Z=N44
XU88 CKMUX2D0BWP7T $PINS I0=n62 I1=key[96] S=n1 Z=N43
XU89 CKMUX2D0BWP7T $PINS I0=n63 I1=key[31] S=n1 Z=N272
XU90 CKXOR2D0BWP7T $PINS A1=wo_3[31] A2=n64 Z=n63
XU91 CKMUX2D0BWP7T $PINS I0=n65 I1=key[30] S=n1 Z=N271
XU92 CKXOR2D0BWP7T $PINS A1=wo_3[30] A2=n66 Z=n65
XU93 CKMUX2D0BWP7T $PINS I0=n67 I1=key[29] S=n1 Z=N270
XU94 CKXOR2D0BWP7T $PINS A1=wo_3[29] A2=n68 Z=n67
XU95 CKMUX2D0BWP7T $PINS I0=n69 I1=key[28] S=n1 Z=N269
XU96 CKXOR2D0BWP7T $PINS A1=wo_3[28] A2=n70 Z=n69
XU97 CKMUX2D0BWP7T $PINS I0=n71 I1=key[27] S=n1 Z=N268
XU98 CKXOR2D0BWP7T $PINS A1=wo_3[27] A2=n72 Z=n71
XU99 CKMUX2D0BWP7T $PINS I0=n73 I1=key[26] S=n1 Z=N267
XU100 CKXOR2D0BWP7T $PINS A1=wo_3[26] A2=n74 Z=n73
XU101 CKMUX2D0BWP7T $PINS I0=n75 I1=key[25] S=n1 Z=N266
XU102 CKXOR2D0BWP7T $PINS A1=wo_3[25] A2=n76 Z=n75
XU103 CKMUX2D0BWP7T $PINS I0=n77 I1=key[24] S=n1 Z=N265
XU104 CKXOR2D0BWP7T $PINS A1=wo_3[24] A2=n78 Z=n77
XU105 CKMUX2D0BWP7T $PINS I0=n79 I1=key[23] S=n1 Z=N264
XU106 CKXOR2D0BWP7T $PINS A1=wo_3[23] A2=n80 Z=n79
XU107 CKMUX2D0BWP7T $PINS I0=n81 I1=key[22] S=n1 Z=N263
XU108 CKXOR2D0BWP7T $PINS A1=wo_3[22] A2=n82 Z=n81
XU109 CKMUX2D0BWP7T $PINS I0=n83 I1=key[21] S=n1 Z=N262
XU110 CKXOR2D0BWP7T $PINS A1=wo_3[21] A2=n84 Z=n83
XU111 CKMUX2D0BWP7T $PINS I0=n85 I1=key[20] S=n1 Z=N261
XU112 CKXOR2D0BWP7T $PINS A1=wo_3[20] A2=n86 Z=n85
XU113 CKMUX2D0BWP7T $PINS I0=n87 I1=key[19] S=n1 Z=N260
XU114 CKXOR2D0BWP7T $PINS A1=wo_3[19] A2=n88 Z=n87
XU115 CKMUX2D0BWP7T $PINS I0=n89 I1=key[18] S=n1 Z=N259
XU116 CKXOR2D0BWP7T $PINS A1=wo_3[18] A2=n90 Z=n89
XU117 CKMUX2D0BWP7T $PINS I0=n91 I1=key[17] S=n1 Z=N258
XU118 CKXOR2D0BWP7T $PINS A1=wo_3[17] A2=n92 Z=n91
XU119 CKMUX2D0BWP7T $PINS I0=n93 I1=key[16] S=n1 Z=N257
XU120 CKXOR2D0BWP7T $PINS A1=wo_3[16] A2=n94 Z=n93
XU121 CKMUX2D0BWP7T $PINS I0=n95 I1=key[15] S=n1 Z=N256
XU122 CKXOR2D0BWP7T $PINS A1=wo_3[15] A2=n96 Z=n95
XU123 CKMUX2D0BWP7T $PINS I0=n97 I1=key[14] S=n1 Z=N255
XU124 CKXOR2D0BWP7T $PINS A1=wo_3[14] A2=n98 Z=n97
XU125 CKMUX2D0BWP7T $PINS I0=n99 I1=key[13] S=n1 Z=N254
XU126 CKXOR2D0BWP7T $PINS A1=wo_3[13] A2=n100 Z=n99
XU127 CKMUX2D0BWP7T $PINS I0=n101 I1=key[12] S=n1 Z=N253
XU128 CKXOR2D0BWP7T $PINS A1=wo_3[12] A2=n102 Z=n101
XU129 CKMUX2D0BWP7T $PINS I0=n103 I1=key[11] S=n1 Z=N252
XU130 CKXOR2D0BWP7T $PINS A1=wo_3[11] A2=n104 Z=n103
XU131 CKMUX2D0BWP7T $PINS I0=n105 I1=key[10] S=n1 Z=N251
XU132 CKXOR2D0BWP7T $PINS A1=wo_3[10] A2=n106 Z=n105
XU133 CKMUX2D0BWP7T $PINS I0=n107 I1=key[9] S=n1 Z=N250
XU134 CKXOR2D0BWP7T $PINS A1=wo_3[9] A2=n108 Z=n107
XU135 CKMUX2D0BWP7T $PINS I0=n109 I1=key[8] S=n1 Z=N249
XU136 CKXOR2D0BWP7T $PINS A1=wo_3[8] A2=n110 Z=n109
XU137 CKMUX2D0BWP7T $PINS I0=n111 I1=key[7] S=n1 Z=N248
XU138 CKXOR2D0BWP7T $PINS A1=wo_3[7] A2=n112 Z=n111
XU139 CKMUX2D0BWP7T $PINS I0=n113 I1=key[6] S=n1 Z=N247
XU140 CKXOR2D0BWP7T $PINS A1=wo_3[6] A2=n114 Z=n113
XU141 CKMUX2D0BWP7T $PINS I0=n115 I1=key[5] S=n1 Z=N246
XU142 CKXOR2D0BWP7T $PINS A1=wo_3[5] A2=n116 Z=n115
XU143 CKMUX2D0BWP7T $PINS I0=n117 I1=key[4] S=n1 Z=N245
XU144 CKXOR2D0BWP7T $PINS A1=wo_3[4] A2=n118 Z=n117
XU145 CKMUX2D0BWP7T $PINS I0=n119 I1=key[3] S=n1 Z=N244
XU146 CKXOR2D0BWP7T $PINS A1=wo_3[3] A2=n120 Z=n119
XU147 CKMUX2D0BWP7T $PINS I0=n121 I1=key[2] S=n1 Z=N243
XU148 CKXOR2D0BWP7T $PINS A1=wo_3[2] A2=n122 Z=n121
XU149 CKMUX2D0BWP7T $PINS I0=n123 I1=key[1] S=n1 Z=N242
XU150 CKXOR2D0BWP7T $PINS A1=wo_3[1] A2=n124 Z=n123
XU151 CKMUX2D0BWP7T $PINS I0=n125 I1=key[0] S=n1 Z=N241
XU152 CKXOR2D0BWP7T $PINS A1=wo_3[0] A2=n126 Z=n125
XU153 CKMUX2D0BWP7T $PINS I0=n64 I1=key[63] S=n1 Z=N206
XU154 CKXOR2D0BWP7T $PINS A1=wo_2[31] A2=n127 Z=n64
XU155 CKMUX2D0BWP7T $PINS I0=n66 I1=key[62] S=n1 Z=N205
XU156 CKXOR2D0BWP7T $PINS A1=wo_2[30] A2=n128 Z=n66
XU157 CKMUX2D0BWP7T $PINS I0=n68 I1=key[61] S=n1 Z=N204
XU158 CKXOR2D0BWP7T $PINS A1=wo_2[29] A2=n129 Z=n68
XU159 CKMUX2D0BWP7T $PINS I0=n70 I1=key[60] S=n1 Z=N203
XU160 CKXOR2D0BWP7T $PINS A1=wo_2[28] A2=n130 Z=n70
XU161 CKMUX2D0BWP7T $PINS I0=n72 I1=key[59] S=n1 Z=N202
XU162 CKXOR2D0BWP7T $PINS A1=wo_2[27] A2=n131 Z=n72
XU163 CKMUX2D0BWP7T $PINS I0=n74 I1=key[58] S=n1 Z=N201
XU164 CKXOR2D0BWP7T $PINS A1=wo_2[26] A2=n132 Z=n74
XU165 CKMUX2D0BWP7T $PINS I0=n76 I1=key[57] S=n1 Z=N200
XU166 CKXOR2D0BWP7T $PINS A1=wo_2[25] A2=n133 Z=n76
XU167 CKMUX2D0BWP7T $PINS I0=n78 I1=key[56] S=n1 Z=N199
XU168 CKXOR2D0BWP7T $PINS A1=wo_2[24] A2=n134 Z=n78
XU169 CKMUX2D0BWP7T $PINS I0=n80 I1=key[55] S=n1 Z=N198
XU170 CKXOR2D0BWP7T $PINS A1=wo_2[23] A2=n135 Z=n80
XU171 CKMUX2D0BWP7T $PINS I0=n82 I1=key[54] S=n1 Z=N197
XU172 CKXOR2D0BWP7T $PINS A1=wo_2[22] A2=n136 Z=n82
XU173 CKMUX2D0BWP7T $PINS I0=n84 I1=key[53] S=n1 Z=N196
XU174 CKXOR2D0BWP7T $PINS A1=wo_2[21] A2=n137 Z=n84
XU175 CKMUX2D0BWP7T $PINS I0=n86 I1=key[52] S=n1 Z=N195
XU176 CKXOR2D0BWP7T $PINS A1=wo_2[20] A2=n138 Z=n86
XU177 CKMUX2D0BWP7T $PINS I0=n88 I1=key[51] S=n1 Z=N194
XU178 CKXOR2D0BWP7T $PINS A1=wo_2[19] A2=n139 Z=n88
XU179 CKMUX2D0BWP7T $PINS I0=n90 I1=key[50] S=n1 Z=N193
XU180 CKXOR2D0BWP7T $PINS A1=wo_2[18] A2=n140 Z=n90
XU181 CKMUX2D0BWP7T $PINS I0=n92 I1=key[49] S=n1 Z=N192
XU182 CKXOR2D0BWP7T $PINS A1=wo_2[17] A2=n141 Z=n92
XU183 CKMUX2D0BWP7T $PINS I0=n94 I1=key[48] S=n1 Z=N191
XU184 CKXOR2D0BWP7T $PINS A1=wo_2[16] A2=n142 Z=n94
XU185 CKMUX2D0BWP7T $PINS I0=n96 I1=key[47] S=n1 Z=N190
XU186 CKXOR2D0BWP7T $PINS A1=wo_2[15] A2=n143 Z=n96
XU187 CKMUX2D0BWP7T $PINS I0=n98 I1=key[46] S=n1 Z=N189
XU188 CKXOR2D0BWP7T $PINS A1=wo_2[14] A2=n144 Z=n98
XU189 CKMUX2D0BWP7T $PINS I0=n100 I1=key[45] S=n1 Z=N188
XU190 CKXOR2D0BWP7T $PINS A1=wo_2[13] A2=n145 Z=n100
XU191 CKMUX2D0BWP7T $PINS I0=n102 I1=key[44] S=n1 Z=N187
XU192 CKXOR2D0BWP7T $PINS A1=wo_2[12] A2=n146 Z=n102
XU193 CKMUX2D0BWP7T $PINS I0=n104 I1=key[43] S=n1 Z=N186
XU194 CKXOR2D0BWP7T $PINS A1=wo_2[11] A2=n147 Z=n104
XU195 CKMUX2D0BWP7T $PINS I0=n106 I1=key[42] S=n1 Z=N185
XU196 CKXOR2D0BWP7T $PINS A1=wo_2[10] A2=n148 Z=n106
XU197 CKMUX2D0BWP7T $PINS I0=n108 I1=key[41] S=n1 Z=N184
XU198 CKXOR2D0BWP7T $PINS A1=wo_2[9] A2=n149 Z=n108
XU199 CKMUX2D0BWP7T $PINS I0=n110 I1=key[40] S=n1 Z=N183
XU200 CKXOR2D0BWP7T $PINS A1=wo_2[8] A2=n150 Z=n110
XU201 CKMUX2D0BWP7T $PINS I0=n112 I1=key[39] S=n1 Z=N182
XU202 CKXOR2D0BWP7T $PINS A1=wo_2[7] A2=n151 Z=n112
XU203 CKMUX2D0BWP7T $PINS I0=n114 I1=key[38] S=n1 Z=N181
XU204 CKXOR2D0BWP7T $PINS A1=wo_2[6] A2=n152 Z=n114
XU205 CKMUX2D0BWP7T $PINS I0=n116 I1=key[37] S=n1 Z=N180
XU206 CKXOR2D0BWP7T $PINS A1=wo_2[5] A2=n153 Z=n116
XU207 CKMUX2D0BWP7T $PINS I0=n118 I1=key[36] S=n1 Z=N179
XU208 CKXOR2D0BWP7T $PINS A1=wo_2[4] A2=n154 Z=n118
XU209 CKMUX2D0BWP7T $PINS I0=n120 I1=key[35] S=n1 Z=N178
XU210 CKXOR2D0BWP7T $PINS A1=wo_2[3] A2=n155 Z=n120
XU211 CKMUX2D0BWP7T $PINS I0=n122 I1=key[34] S=n1 Z=N177
XU212 CKXOR2D0BWP7T $PINS A1=wo_2[2] A2=n156 Z=n122
XU213 CKMUX2D0BWP7T $PINS I0=n124 I1=key[33] S=n1 Z=N176
XU214 CKXOR2D0BWP7T $PINS A1=wo_2[1] A2=n157 Z=n124
XU215 CKMUX2D0BWP7T $PINS I0=n126 I1=key[32] S=n1 Z=N175
XU216 CKXOR2D0BWP7T $PINS A1=wo_2[0] A2=n158 Z=n126
XU217 CKMUX2D0BWP7T $PINS I0=n127 I1=key[95] S=n1 Z=N140
XU218 CKXOR2D0BWP7T $PINS A1=wo_1[31] A2=n31 Z=n127
XU219 XOR3D0BWP7T $PINS A1=wo_0[31] A2=subword[31] A3=rcon[31] Z=n31
XU220 CKMUX2D0BWP7T $PINS I0=n128 I1=key[94] S=n1 Z=N139
XU221 CKXOR2D0BWP7T $PINS A1=wo_1[30] A2=n32 Z=n128
XU222 XOR3D0BWP7T $PINS A1=wo_0[30] A2=subword[30] A3=rcon[30] Z=n32
XU223 CKMUX2D0BWP7T $PINS I0=n129 I1=key[93] S=n1 Z=N138
XU224 CKXOR2D0BWP7T $PINS A1=wo_1[29] A2=n33 Z=n129
XU225 XOR3D0BWP7T $PINS A1=wo_0[29] A2=subword[29] A3=rcon[29] Z=n33
XU226 CKMUX2D0BWP7T $PINS I0=n130 I1=key[92] S=n1 Z=N137
XU227 CKXOR2D0BWP7T $PINS A1=wo_1[28] A2=n34 Z=n130
XU228 XOR3D0BWP7T $PINS A1=wo_0[28] A2=subword[28] A3=rcon[28] Z=n34
XU229 CKMUX2D0BWP7T $PINS I0=n131 I1=key[91] S=n1 Z=N136
XU230 CKXOR2D0BWP7T $PINS A1=wo_1[27] A2=n35 Z=n131
XU231 XOR3D0BWP7T $PINS A1=wo_0[27] A2=subword[27] A3=rcon[27] Z=n35
XU232 CKMUX2D0BWP7T $PINS I0=n132 I1=key[90] S=n1 Z=N135
XU233 CKXOR2D0BWP7T $PINS A1=wo_1[26] A2=n36 Z=n132
XU234 XOR3D0BWP7T $PINS A1=wo_0[26] A2=subword[26] A3=rcon[26] Z=n36
XU235 CKMUX2D0BWP7T $PINS I0=n133 I1=key[89] S=n1 Z=N134
XU236 CKXOR2D0BWP7T $PINS A1=wo_1[25] A2=n37 Z=n133
XU237 XOR3D0BWP7T $PINS A1=wo_0[25] A2=subword[25] A3=rcon[25] Z=n37
XU238 CKMUX2D0BWP7T $PINS I0=n134 I1=key[88] S=n1 Z=N133
XU239 CKXOR2D0BWP7T $PINS A1=wo_1[24] A2=n38 Z=n134
XU240 XOR3D0BWP7T $PINS A1=wo_0[24] A2=subword[24] A3=rcon[24] Z=n38
XU241 CKMUX2D0BWP7T $PINS I0=n135 I1=key[87] S=n1 Z=N132
XU242 CKXOR2D0BWP7T $PINS A1=wo_1[23] A2=n39 Z=n135
XU243 CKMUX2D0BWP7T $PINS I0=n136 I1=key[86] S=n2 Z=N131
XU244 CKXOR2D0BWP7T $PINS A1=wo_1[22] A2=n40 Z=n136
XU245 CKMUX2D0BWP7T $PINS I0=n137 I1=key[85] S=n2 Z=N130
XU246 CKXOR2D0BWP7T $PINS A1=wo_1[21] A2=n41 Z=n137
XU247 CKMUX2D0BWP7T $PINS I0=n138 I1=key[84] S=n2 Z=N129
XU248 CKXOR2D0BWP7T $PINS A1=wo_1[20] A2=n42 Z=n138
XU249 CKMUX2D0BWP7T $PINS I0=n139 I1=key[83] S=n2 Z=N128
XU250 CKXOR2D0BWP7T $PINS A1=wo_1[19] A2=n43 Z=n139
XU251 CKMUX2D0BWP7T $PINS I0=n140 I1=key[82] S=n2 Z=N127
XU252 CKXOR2D0BWP7T $PINS A1=wo_1[18] A2=n44 Z=n140
XU253 CKMUX2D0BWP7T $PINS I0=n141 I1=key[81] S=n2 Z=N126
XU254 CKXOR2D0BWP7T $PINS A1=wo_1[17] A2=n45 Z=n141
XU255 CKMUX2D0BWP7T $PINS I0=n142 I1=key[80] S=n2 Z=N125
XU256 CKXOR2D0BWP7T $PINS A1=wo_1[16] A2=n46 Z=n142
XU257 CKMUX2D0BWP7T $PINS I0=n143 I1=key[79] S=n2 Z=N124
XU258 CKXOR2D0BWP7T $PINS A1=wo_1[15] A2=n47 Z=n143
XU259 CKMUX2D0BWP7T $PINS I0=n144 I1=key[78] S=n2 Z=N123
XU260 CKXOR2D0BWP7T $PINS A1=wo_1[14] A2=n48 Z=n144
XU261 CKMUX2D0BWP7T $PINS I0=n145 I1=key[77] S=n2 Z=N122
XU262 CKXOR2D0BWP7T $PINS A1=wo_1[13] A2=n49 Z=n145
XU263 CKMUX2D0BWP7T $PINS I0=n146 I1=key[76] S=n2 Z=N121
XU264 CKXOR2D0BWP7T $PINS A1=wo_1[12] A2=n50 Z=n146
XU265 CKMUX2D0BWP7T $PINS I0=n147 I1=key[75] S=n2 Z=N120
XU266 CKXOR2D0BWP7T $PINS A1=wo_1[11] A2=n51 Z=n147
XU267 CKMUX2D0BWP7T $PINS I0=n148 I1=key[74] S=n2 Z=N119
XU268 CKXOR2D0BWP7T $PINS A1=wo_1[10] A2=n52 Z=n148
XU269 CKMUX2D0BWP7T $PINS I0=n149 I1=key[73] S=n2 Z=N118
XU270 CKXOR2D0BWP7T $PINS A1=wo_1[9] A2=n53 Z=n149
XU271 CKMUX2D0BWP7T $PINS I0=n150 I1=key[72] S=n2 Z=N117
XU272 CKXOR2D0BWP7T $PINS A1=wo_1[8] A2=n54 Z=n150
XU273 CKMUX2D0BWP7T $PINS I0=n151 I1=key[71] S=n2 Z=N116
XU274 CKXOR2D0BWP7T $PINS A1=wo_1[7] A2=n55 Z=n151
XU275 CKMUX2D0BWP7T $PINS I0=n152 I1=key[70] S=n2 Z=N115
XU276 CKXOR2D0BWP7T $PINS A1=wo_1[6] A2=n56 Z=n152
XU277 CKMUX2D0BWP7T $PINS I0=n153 I1=key[69] S=n2 Z=N114
XU278 CKXOR2D0BWP7T $PINS A1=wo_1[5] A2=n57 Z=n153
XU279 CKMUX2D0BWP7T $PINS I0=n154 I1=key[68] S=n2 Z=N113
XU280 CKXOR2D0BWP7T $PINS A1=wo_1[4] A2=n58 Z=n154
XU281 CKMUX2D0BWP7T $PINS I0=n155 I1=key[67] S=n2 Z=N112
XU282 CKXOR2D0BWP7T $PINS A1=wo_1[3] A2=n59 Z=n155
XU283 CKMUX2D0BWP7T $PINS I0=n156 I1=key[66] S=n2 Z=N111
XU284 CKXOR2D0BWP7T $PINS A1=wo_1[2] A2=n60 Z=n156
XU285 CKMUX2D0BWP7T $PINS I0=n157 I1=key[65] S=n2 Z=N110
XU286 CKXOR2D0BWP7T $PINS A1=wo_1[1] A2=n61 Z=n157
XU287 CKMUX2D0BWP7T $PINS I0=n158 I1=key[64] S=n2 Z=N109
XU288 CKXOR2D0BWP7T $PINS A1=wo_1[0] A2=n62 Z=n158
.ENDS

.SUBCKT aes_sbox_0 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_5 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_6 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_7 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_8 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_9 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_10 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_11 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_12 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_13 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_14 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_15 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_16 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_17 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_18 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_sbox_19 a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] d[7] d[6] d[5] d[4]
+ d[3] d[2] d[1] d[0]
XU3 IND4D0BWP7T $PINS A1=n1 B1=n2 B2=n3 B3=n4 ZN=d[7]
XU4 NR4D0BWP7T $PINS A1=n5 A2=n6 A3=n7 A4=n8 ZN=n4
XU5 AOI21D0BWP7T $PINS A1=n9 A2=n10 B=n11 ZN=n8
XU6 AOI21D0BWP7T $PINS A1=n12 A2=n13 B=n14 ZN=n7
XU7 OAI22D0BWP7T $PINS A1=n15 A2=n16 B1=n17 B2=n18 ZN=n6
XU8 OAI222D0BWP7T $PINS A1=n19 A2=n20 B1=n21 B2=n22 C1=n23 C2=n24 ZN=n5
XU9 NR3D0BWP7T $PINS A1=n25 A2=n26 A3=n27 ZN=n3
XU10 AOI22D0BWP7T $PINS A1=n28 A2=n29 B1=n30 B2=n31 ZN=n2
XU11 ND4D0BWP7T $PINS A1=n32 A2=n33 A3=n34 A4=n35 ZN=d[6]
XU12 AOI211D0BWP7T $PINS A1=n36 A2=n37 B=n38 C=n39 ZN=n35
XU13 AOI21D0BWP7T $PINS A1=n40 A2=n41 B=n22 ZN=n39
XU14 OAI22D0BWP7T $PINS A1=n42 A2=n43 B1=n44 B2=n45 ZN=n38
XU15 AOI221D0BWP7T $PINS A1=n46 A2=n47 B1=n48 B2=n49 C=n50 ZN=n34
XU16 OAI22D0BWP7T $PINS A1=n51 A2=n52 B1=n12 B2=n53 ZN=n50
XU17 AOI221D0BWP7T $PINS A1=n54 A2=n55 B1=n56 B2=n57 C=n58 ZN=n33
XU18 OAI22D0BWP7T $PINS A1=n59 A2=n60 B1=n61 B2=n62 ZN=n58
XU19 NR4D0BWP7T $PINS A1=n63 A2=n1 A3=n64 A4=n65 ZN=n32
XU20 ND4D0BWP7T $PINS A1=n66 A2=n67 A3=n68 A4=n69 ZN=n1
XU21 AOI211D0BWP7T $PINS A1=n56 A2=n70 B=n71 C=n72 ZN=n69
XU22 AOI21D0BWP7T $PINS A1=n73 A2=n51 B=n74 ZN=n72
XU23 AOI21D0BWP7T $PINS A1=n17 A2=n59 B=n14 ZN=n71
XU24 NR2D0BWP7T $PINS A1=n75 A2=n30 ZN=n17
XU25 AOI222D0BWP7T $PINS A1=n48 A2=n76 B1=n77 B2=n78 C1=n79 C2=n80 ZN=n68
XU26 AOI222D0BWP7T $PINS A1=n30 A2=n57 B1=n75 B2=n55 C1=n81 C2=n82 ZN=n67
XU27 AOI22D0BWP7T $PINS A1=n83 A2=n84 B1=n36 B2=n29 ZN=n66
XU28 IND4D0BWP7T $PINS A1=n85 B1=n86 B2=n87 B3=n88 ZN=d[5]
XU29 NR4D0BWP7T $PINS A1=n89 A2=n90 A3=n91 A4=n92 ZN=n88
XU30 AOI21D0BWP7T $PINS A1=n93 A2=n94 B=n95 ZN=n92
XU31 IAO21D0BWP7T $PINS A1=n96 A2=n28 B=n51 ZN=n91
XU32 MOAI22D0BWP7T $PINS A1=n97 A2=n53 B1=n70 B2=n30 ZN=n90
XU33 OAI222D0BWP7T $PINS A1=n98 A2=n94 B1=n99 B2=n43 C1=n22 C2=n18 ZN=n89
XU34 INR3D0BWP7T $PINS A1=n100 B1=n101 B2=n102 ZN=n87
XU35 AOI22D0BWP7T $PINS A1=n48 A2=n55 B1=n75 B2=n81 ZN=n86
XU36 ND4D0BWP7T $PINS A1=n103 A2=n104 A3=n105 A4=n106 ZN=d[4]
XU37 NR4D0BWP7T $PINS A1=n107 A2=n108 A3=n109 A4=n110 ZN=n106
XU38 IAO21D0BWP7T $PINS A1=n111 A2=n54 B=n95 ZN=n110
XU39 AOI21D0BWP7T $PINS A1=n41 A2=n20 B=n112 ZN=n109
XU40 OAI22D0BWP7T $PINS A1=n11 A2=n94 B1=n113 B2=n10 ZN=n108
XU41 OAI222D0BWP7T $PINS A1=n74 A2=n22 B1=n59 B2=n53 C1=n45 C2=n52 ZN=n107
XU42 AOI211D0BWP7T $PINS A1=n114 A2=n115 B=n116 C=n117 ZN=n105
XU43 OAI22D0BWP7T $PINS A1=n13 A2=n98 B1=n9 B2=n14 ZN=n116
XU44 NR2D0BWP7T $PINS A1=n85 A2=n118 ZN=n103
XU45 ND4D0BWP7T $PINS A1=n119 A2=n120 A3=n121 A4=n122 ZN=n85
XU46 AOI211D0BWP7T $PINS A1=n29 A2=n123 B=n124 C=n125 ZN=n122
XU47 AOI21D0BWP7T $PINS A1=n51 A2=n126 B=n127 ZN=n125
XU48 AOI21D0BWP7T $PINS A1=n24 A2=n95 B=n13 ZN=n124
XU49 AOI222D0BWP7T $PINS A1=n28 A2=n56 B1=n128 B2=n129 C1=n115 C2=n130 ZN=n121
XU50 AOI222D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n47 C1=n48 C2=n131 ZN=n120
XU51 AOI22D0BWP7T $PINS A1=n81 A2=n132 B1=n83 B2=n78 ZN=n119
XU52 ND3D0BWP7T $PINS A1=n133 A2=n134 A3=n135 ZN=d[3]
XU53 NR4D0BWP7T $PINS A1=n136 A2=n137 A3=n138 A4=n139 ZN=n135
XU54 AOI21D0BWP7T $PINS A1=n59 A2=n10 B=n95 ZN=n139
XU55 AOI22D0BWP7T $PINS A1=n74 A2=n18 B1=n140 B2=n141 ZN=n138
XU56 OAI22D0BWP7T $PINS A1=n142 A2=n24 B1=n97 B2=n127 ZN=n137
XU57 NR2D0BWP7T $PINS A1=n30 A2=n143 ZN=n97
XU58 OAI222D0BWP7T $PINS A1=n9 A2=n52 B1=n11 B2=n94 C1=n20 C2=n45 ZN=n136
XU59 AOI211D0BWP7T $PINS A1=n75 A2=n144 B=n145 C=n146 ZN=n134
XU60 OAI22D0BWP7T $PINS A1=n12 A2=n41 B1=n13 B2=n40 ZN=n145
XU61 NR3D0BWP7T $PINS A1=n147 A2=n27 A3=n64 ZN=n133
XU62 IIND4D0BWP7T $PINS A1=n148 A2=n26 B1=n149 B2=n150 ZN=n64
XU63 NR4D0BWP7T $PINS A1=n151 A2=n152 A3=n153 A4=n154 ZN=n150
XU64 AOI21D0BWP7T $PINS A1=n74 A2=n53 B=n155 ZN=n154
XU65 AOI21D0BWP7T $PINS A1=n24 A2=n61 B=n13 ZN=n153
XU66 AOI21D0BWP7T $PINS A1=n73 A2=n22 B=n98 ZN=n152
XU67 NR2D0BWP7T $PINS A1=n83 A2=n46 ZN=n73
XU68 OAI222D0BWP7T $PINS A1=n156 A2=n12 B1=n157 B2=n60 C1=n23 C2=n18 ZN=n151
XU69 CKND0BWP7T $PINS I=n158 ZN=n157
XU70 AOI221D0BWP7T $PINS A1=n77 A2=n36 B1=n56 B2=n84 C=n159 ZN=n149
XU71 ND4D0BWP7T $PINS A1=n160 A2=n161 A3=n162 A4=n163 ZN=n26
XU72 AOI211D0BWP7T $PINS A1=n28 A2=n164 B=n165 C=n166 ZN=n163
XU73 AOI21D0BWP7T $PINS A1=n51 A2=n94 B=n14 ZN=n166
XU74 IAO21D0BWP7T $PINS A1=n167 A2=n31 B=n22 ZN=n165
XU75 AOI22D0BWP7T $PINS A1=n115 A2=n168 B1=n143 B2=n169 ZN=n162
XU76 AOI222D0BWP7T $PINS A1=n131 A2=n80 B1=n48 B2=n144 C1=n56 C2=n55 ZN=n161
XU77 AOI22D0BWP7T $PINS A1=n83 A2=n57 B1=n84 B2=n170 ZN=n160
XU78 ND4D0BWP7T $PINS A1=n171 A2=n172 A3=n173 A4=n174 ZN=n27
XU79 AOI211D0BWP7T $PINS A1=n81 A2=n175 B=n176 C=n177 ZN=n174
XU80 AOI21D0BWP7T $PINS A1=n140 A2=n45 B=n95 ZN=n177
XU81 AOI21D0BWP7T $PINS A1=n156 A2=n74 B=n16 ZN=n176
XU82 AOI22D0BWP7T $PINS A1=n30 A2=n178 B1=n82 B2=n179 ZN=n173
XU83 AOI22D0BWP7T $PINS A1=n75 A2=n180 B1=n47 B2=n128 ZN=n172
XU84 AOI22D0BWP7T $PINS A1=n83 A2=n55 B1=n46 B2=n144 ZN=n171
XU85 ND4D0BWP7T $PINS A1=n181 A2=n100 A3=n182 A4=n183 ZN=d[2]
XU86 NR4D0BWP7T $PINS A1=n184 A2=n185 A3=n186 A4=n187 ZN=n183
XU87 AOI21D0BWP7T $PINS A1=n188 A2=n13 B=n40 ZN=n187
XU88 AOI21D0BWP7T $PINS A1=n189 A2=n9 B=n41 ZN=n186
XU89 MOAI22D0BWP7T $PINS A1=n190 A2=n155 B1=n37 B2=n79 ZN=n185
XU90 CKND2D0BWP7T $PINS A1=n141 A2=n51 ZN=n37
XU91 OAI222D0BWP7T $PINS A1=n60 A2=n94 B1=n191 B2=n51 C1=n62 C2=n18 ZN=n184
XU92 NR3D0BWP7T $PINS A1=n192 A2=n193 A3=n118 ZN=n182
XU93 ND4D0BWP7T $PINS A1=n194 A2=n195 A3=n196 A4=n197 ZN=n118
XU94 AOI221D0BWP7T $PINS A1=n96 A2=n168 B1=n57 B2=n198 C=n199 ZN=n197
XU95 OAI22D0BWP7T $PINS A1=n10 A2=n127 B1=n200 B2=n62 ZN=n199
XU96 CKND0BWP7T $PINS I=n19 ZN=n198
XU97 OA22D0BWP7T $PINS A1=n12 A2=n44 B1=n14 B2=n201 Z=n196
XU98 NR2D0BWP7T $PINS A1=n84 A2=n79 ZN=n44
XU99 OAI21D0BWP7T $PINS A1=n48 A2=n170 B=n28 ZN=n195
XU100 OAI21D0BWP7T $PINS A1=n55 A2=n144 B=n80 ZN=n194
XU101 IINR4D0BWP7T $PINS A1=n202 A2=n203 B1=n204 B2=n205 ZN=n100
XU102 NR4D0BWP7T $PINS A1=n206 A2=n207 A3=n208 A4=n209 ZN=n203
XU103 AOI21D0BWP7T $PINS A1=n210 A2=n10 B=n74 ZN=n209
XU104 AOI21D0BWP7T $PINS A1=n40 A2=n60 B=n22 ZN=n208
XU105 AOI21D0BWP7T $PINS A1=n113 A2=n60 B=n141 ZN=n207
XU106 AO221D0BWP7T $PINS A1=n211 A2=n83 B1=n129 B2=n56 C=n212 Z=n206
XU107 AOI21D0BWP7T $PINS A1=n18 A2=n24 B=n140 ZN=n212
XU108 AOI221D0BWP7T $PINS A1=n47 A2=n114 B1=n132 B2=n115 C=n117 ZN=n202
XU109 ND4D0BWP7T $PINS A1=n213 A2=n214 A3=n215 A4=n216 ZN=n117
XU110 OA221D0BWP7T $PINS A1=n127 A2=n217 B1=n13 B2=n190 C=n218 Z=n216
XU111 AO21D0BWP7T $PINS A1=n210 A2=n12 B=n24 Z=n218
XU112 NR2D0BWP7T $PINS A1=n78 A2=n115 ZN=n190
XU113 OA222D0BWP7T $PINS A1=n126 A2=n40 B1=n20 B2=n189 C1=n14 C2=n141 Z=n215
XU114 NR2D0BWP7T $PINS A1=n83 A2=n30 ZN=n189
XU115 AOI222D0BWP7T $PINS A1=n81 A2=n114 B1=n56 B2=n144 C1=n131 C2=n80 ZN=n214
XU116 AOI22D0BWP7T $PINS A1=n83 A2=n115 B1=n75 B2=n76 ZN=n213
XU117 AOI22D0BWP7T $PINS A1=n131 A2=n114 B1=n29 B2=n76 ZN=n181
XU118 ND3D0BWP7T $PINS A1=n219 A2=n220 A3=n221 ZN=d[1]
XU119 NR4D0BWP7T $PINS A1=n222 A2=n223 A3=n224 A4=n225 ZN=n221
XU120 AOI21D0BWP7T $PINS A1=n226 A2=n22 B=n24 ZN=n225
XU121 AOI21D0BWP7T $PINS A1=n18 A2=n14 B=n13 ZN=n224
XU122 OAI22D0BWP7T $PINS A1=n227 A2=n41 B1=n201 B2=n98 ZN=n223
XU123 NR2D0BWP7T $PINS A1=n132 A2=n128 ZN=n201
XU124 OAI222D0BWP7T $PINS A1=n53 A2=n45 B1=n228 B2=n141 C1=n10 C2=n52 ZN=n222
XU125 AOI211D0BWP7T $PINS A1=n36 A2=n80 B=n229 C=n204 ZN=n220
XU126 ND4D0BWP7T $PINS A1=n230 A2=n231 A3=n232 A4=n233 ZN=n204
XU127 AOI211D0BWP7T $PINS A1=n170 A2=n234 B=n235 C=n236 ZN=n233
XU128 AOI21D0BWP7T $PINS A1=n40 A2=n52 B=n59 ZN=n236
XU129 IAO21D0BWP7T $PINS A1=n179 A2=n237 B=n9 ZN=n235
XU130 CKND2D0BWP7T $PINS A1=n99 A2=n200 ZN=n234
XU131 MAOI22D0BWP7T $PINS A1=n46 A2=n70 B1=n61 B2=n210 ZN=n232
XU132 CKND2D0BWP7T $PINS A1=n60 A2=n18 ZN=n70
XU133 AOI22D0BWP7T $PINS A1=n48 A2=n47 B1=n144 B2=n82 ZN=n231
XU134 AOI22D0BWP7T $PINS A1=n81 A2=n143 B1=n76 B2=n114 ZN=n230
XU135 OAI22D0BWP7T $PINS A1=n74 A2=n43 B1=n51 B2=n14 ZN=n229
XU136 INR3D0BWP7T $PINS A1=n104 B1=n192 B2=n101 ZN=n219
XU137 ND4D0BWP7T $PINS A1=n238 A2=n239 A3=n240 A4=n241 ZN=n101
XU138 AOI211D0BWP7T $PINS A1=n78 A2=n242 B=n243 C=n244 ZN=n241
XU139 AOI21D0BWP7T $PINS A1=n228 A2=n60 B=n126 ZN=n244
XU140 AOI21D0BWP7T $PINS A1=n11 A2=n41 B=n140 ZN=n243
XU141 CKND2D0BWP7T $PINS A1=n93 A2=n51 ZN=n242
XU142 AOI22D0BWP7T $PINS A1=n80 A2=n167 B1=n77 B2=n28 ZN=n240
XU143 AOI222D0BWP7T $PINS A1=n143 A2=n55 B1=n128 B2=n76 C1=n56 C2=n47 ZN=n239
XU144 AOI22D0BWP7T $PINS A1=n237 A2=n114 B1=n83 B2=n131 ZN=n238
XU145 ND4D0BWP7T $PINS A1=n245 A2=n246 A3=n247 A4=n248 ZN=n192
XU146 AOI221D0BWP7T $PINS A1=n83 A2=n178 B1=n29 B2=n211 C=n249 ZN=n248
XU147 AOI21D0BWP7T $PINS A1=n210 A2=n22 B=n95 ZN=n249
XU148 CKND2D0BWP7T $PINS A1=n60 A2=n14 ZN=n211
XU149 CKND2D0BWP7T $PINS A1=n11 A2=n52 ZN=n178
XU150 AOI222D0BWP7T $PINS A1=n36 A2=n128 B1=n30 B2=n180 C1=n48 C2=n79 ZN=n247
XU151 CKND0BWP7T $PINS I=n99 ZN=n180
XU152 NR2D0BWP7T $PINS A1=n36 A2=n57 ZN=n99
XU153 AOI222D0BWP7T $PINS A1=n80 A2=n49 B1=n28 B2=n54 C1=n170 C2=n55 ZN=n246
XU154 AOI22D0BWP7T $PINS A1=n76 A2=n143 B1=n75 B2=n131 ZN=n245
XU155 IINR4D0BWP7T $PINS A1=n250 A2=n251 B1=n193 B2=n102 ZN=n104
XU156 ND3D0BWP7T $PINS A1=n252 A2=n253 A3=n254 ZN=n102
XU157 NR4D0BWP7T $PINS A1=n255 A2=n256 A3=n257 A4=n258 ZN=n254
XU158 AOI21D0BWP7T $PINS A1=n140 A2=n13 B=n74 ZN=n258
XU159 AOI21D0BWP7T $PINS A1=n59 A2=n126 B=n18 ZN=n257
XU160 AOI21D0BWP7T $PINS A1=n141 A2=n45 B=n41 ZN=n256
XU161 OAI21D0BWP7T $PINS A1=n142 A2=n61 B=n259 ZN=n255
XU162 IOA21D0BWP7T $PINS A1=n260 A2=n15 B=n46 ZN=n259
XU163 NR2D0BWP7T $PINS A1=n76 A2=n47 ZN=n15
XU164 AOI22D0BWP7T $PINS A1=n77 A2=n47 B1=n57 B2=n82 ZN=n253
XU165 AOI22D0BWP7T $PINS A1=n84 A2=n75 B1=n144 B2=n114 ZN=n252
XU166 ND4D0BWP7T $PINS A1=n261 A2=n262 A3=n263 A4=n264 ZN=n193
XU167 AOI222D0BWP7T $PINS A1=n56 A2=n265 B1=n75 B2=n266 C1=n84 C2=n267 ZN=n264
XU168 CKND2D0BWP7T $PINS A1=n21 A2=n95 ZN=n266
XU169 AOI22D0BWP7T $PINS A1=n132 A2=n169 B1=n114 B2=n167 ZN=n263
XU170 CKND2D0BWP7T $PINS A1=n61 A2=n52 ZN=n167
XU171 AOI22D0BWP7T $PINS A1=n80 A2=n268 B1=n28 B2=n128 ZN=n262
XU172 AOI22D0BWP7T $PINS A1=n48 A2=n57 B1=n46 B2=n81 ZN=n261
XU173 NR4D0BWP7T $PINS A1=n269 A2=n270 A3=n271 A4=n272 ZN=n251
XU174 AOI21D0BWP7T $PINS A1=n20 A2=n52 B=n62 ZN=n272
XU175 AOI21D0BWP7T $PINS A1=n142 A2=n188 B=n18 ZN=n271
XU176 NR2D0BWP7T $PINS A1=n170 A2=n77 ZN=n142
XU177 AOI21D0BWP7T $PINS A1=n40 A2=n200 B=n140 ZN=n270
XU178 OAI222D0BWP7T $PINS A1=n273 A2=n155 B1=n227 B2=n20 C1=n228 C2=n59 ZN=n269
XU179 NR2D0BWP7T $PINS A1=n76 A2=n49 ZN=n228
XU180 NR2D0BWP7T $PINS A1=n56 A2=n77 ZN=n227
XU181 AOI221D0BWP7T $PINS A1=n131 A2=n82 B1=n83 B2=n31 C=n205 ZN=n250
XU182 ND3D0BWP7T $PINS A1=n274 A2=n275 A3=n276 ZN=n205
XU183 NR4D0BWP7T $PINS A1=n277 A2=n278 A3=n279 A4=n280 ZN=n276
XU184 AOI21D0BWP7T $PINS A1=n45 A2=n13 B=n127 ZN=n280
XU185 IAO21D0BWP7T $PINS A1=n175 A2=n128 B=n61 ZN=n279
XU186 CKND2D0BWP7T $PINS A1=n140 A2=n62 ZN=n175
XU187 AOI21D0BWP7T $PINS A1=n23 A2=n51 B=n200 ZN=n278
XU188 AOI21D0BWP7T $PINS A1=n59 A2=n12 B=n20 ZN=n277
XU189 MAOI22D0BWP7T $PINS A1=n77 A2=n129 B1=n16 B2=n113 ZN=n275
XU190 NR2D0BWP7T $PINS A1=n84 A2=n131 ZN=n113
XU191 CKND2D0BWP7T $PINS A1=n200 A2=n53 ZN=n129
XU192 AOI22D0BWP7T $PINS A1=n48 A2=n81 B1=n54 B2=n144 ZN=n274
XU193 ND4D0BWP7T $PINS A1=n281 A2=n282 A3=n283 A4=n284 ZN=d[0]
XU194 AOI211D0BWP7T $PINS A1=n76 A2=n158 B=n285 C=n286 ZN=n284
XU195 AOI31D0BWP7T $PINS A1=n60 A2=n24 A3=n191 B=n140 ZN=n286
XU196 OAI22D0BWP7T $PINS A1=n287 A2=n127 B1=n226 B2=n200 ZN=n285
XU197 NR2D0BWP7T $PINS A1=n46 A2=n75 ZN=n226
XU198 CKND2D0BWP7T $PINS A1=n188 A2=n12 ZN=n158
XU199 NR2D0BWP7T $PINS A1=n83 A2=n29 ZN=n188
XU200 AOI222D0BWP7T $PINS A1=n29 A2=n81 B1=n48 B2=n55 C1=n30 C2=n84 ZN=n283
XU201 AOI221D0BWP7T $PINS A1=n132 A2=n78 B1=n31 B2=n170 C=n25 ZN=n282
XU202 ND3D0BWP7T $PINS A1=n288 A2=n289 A3=n290 ZN=n25
XU203 NR4D0BWP7T $PINS A1=n291 A2=n292 A3=n293 A4=n294 ZN=n290
XU204 AOI21D0BWP7T $PINS A1=n42 A2=n260 B=n13 ZN=n294
XU205 NR2D0BWP7T $PINS A1=n55 A2=n79 ZN=n260
XU206 AOI21D0BWP7T $PINS A1=n12 A2=n22 B=n74 ZN=n293
XU207 AOI21D0BWP7T $PINS A1=n217 A2=n51 B=n200 ZN=n292
XU208 NR2D0BWP7T $PINS A1=n54 A2=n132 ZN=n217
XU209 OAI222D0BWP7T $PINS A1=n126 A2=n18 B1=n287 B2=n40 C1=n41 C2=n155 ZN=n291
XU210 NR2D0BWP7T $PINS A1=n80 A2=n132 ZN=n287
XU211 AOI222D0BWP7T $PINS A1=n36 A2=n54 B1=n56 B2=n31 C1=n29 C2=n131 ZN=n289
XU212 NR3D0BWP7T $PINS A1=n63 A2=n146 A3=n159 ZN=n288
XU213 ND4D0BWP7T $PINS A1=n295 A2=n296 A3=n297 A4=n298 ZN=n159
XU214 AOI211D0BWP7T $PINS A1=n131 A2=n164 B=n299 C=n300 ZN=n298
XU215 IAO21D0BWP7T $PINS A1=n301 A2=n75 B=n95 ZN=n300
XU216 IAO21D0BWP7T $PINS A1=n164 A2=n143 B=n41 ZN=n299
XU217 CKND2D0BWP7T $PINS A1=n141 A2=n59 ZN=n164
XU218 MAOI22D0BWP7T $PINS A1=n128 A2=n76 B1=n62 B2=n156 ZN=n297
XU219 NR2D0BWP7T $PINS A1=n131 A2=n28 ZN=n156
XU220 AOI222D0BWP7T $PINS A1=n84 A2=n82 B1=n47 B2=n54 C1=n114 C2=n55 ZN=n296
XU221 AOI22D0BWP7T $PINS A1=n143 A2=n115 B1=n57 B2=n132 ZN=n295
XU222 CKND0BWP7T $PINS I=n13 ZN=n143
XU223 OAI211D0BWP7T $PINS A1=n12 A2=n24 B=n302 C=n303 ZN=n146
XU224 NR4D0BWP7T $PINS A1=n304 A2=n305 A3=n306 A4=n307 ZN=n303
XU225 AOI21D0BWP7T $PINS A1=n95 A2=n14 B=n43 ZN=n307
XU226 AOI21D0BWP7T $PINS A1=n308 A2=n41 B=n10 ZN=n306
XU227 AOI21D0BWP7T $PINS A1=n127 A2=n14 B=n126 ZN=n305
XU228 AOI21D0BWP7T $PINS A1=n19 A2=n140 B=n53 ZN=n304
XU229 AOI22D0BWP7T $PINS A1=n144 A2=n267 B1=n55 B2=n111 ZN=n302
XU230 CKND0BWP7T $PINS I=n20 ZN=n55
XU231 CKND2D0BWP7T $PINS A1=n155 A2=n94 ZN=n267
XU232 ND4D0BWP7T $PINS A1=n309 A2=n310 A3=n311 A4=n312 ZN=n63
XU233 AOI211D0BWP7T $PINS A1=n114 A2=n265 B=n313 C=n314 ZN=n312
XU234 AOI21D0BWP7T $PINS A1=n210 A2=n126 B=n200 ZN=n314
XU235 NR2D0BWP7T $PINS A1=n29 A2=n56 ZN=n210
XU236 AOI21D0BWP7T $PINS A1=n10 A2=n155 B=n20 ZN=n313
XU237 CKND2D0BWP7T $PINS A1=n127 A2=n18 ZN=n265
XU238 MAOI22D0BWP7T $PINS A1=n78 A2=n168 B1=n13 B2=n273 ZN=n311
XU239 NR2D0BWP7T $PINS A1=n76 A2=n131 ZN=n273
XU240 CKND2D0BWP7T $PINS A1=n315 A2=n316 ZN=n13
XU241 CKND2D0BWP7T $PINS A1=n12 A2=n155 ZN=n168
XU242 AOI22D0BWP7T $PINS A1=n82 A2=n169 B1=n49 B2=n132 ZN=n310
XU243 CKND2D0BWP7T $PINS A1=n95 A2=n60 ZN=n169
XU244 AOI22D0BWP7T $PINS A1=n80 A2=n144 B1=n76 B2=n170 ZN=n309
XU245 CKND0BWP7T $PINS I=n60 ZN=n144
XU246 NR3D0BWP7T $PINS A1=n147 A2=n148 A3=n65 ZN=n281
XU247 ND4D0BWP7T $PINS A1=n317 A2=n318 A3=n319 A4=n320 ZN=n65
XU248 AOI211D0BWP7T $PINS A1=n83 A2=n321 B=n322 C=n323 ZN=n320
XU249 AOI21D0BWP7T $PINS A1=n60 A2=n200 B=n22 ZN=n323
XU250 AOI31D0BWP7T $PINS A1=n140 A2=n16 A3=n51 B=n61 ZN=n322
XU251 CKND2D0BWP7T $PINS A1=n21 A2=n41 ZN=n321
XU252 NR2D0BWP7T $PINS A1=n36 A2=n79 ZN=n21
XU253 CKND0BWP7T $PINS I=n43 ZN=n83
XU254 CKND2D0BWP7T $PINS A1=n324 A2=n325 ZN=n43
XU255 AOI22D0BWP7T $PINS A1=n82 A2=n123 B1=n75 B2=n268 ZN=n319
XU256 CKND0BWP7T $PINS I=n191 ZN=n268
XU257 NR2D0BWP7T $PINS A1=n76 A2=n84 ZN=n191
XU258 CKND0BWP7T $PINS I=n11 ZN=n76
XU259 CKND2D0BWP7T $PINS A1=n326 A2=n327 ZN=n11
XU260 CKND2D0BWP7T $PINS A1=n98 A2=n20 ZN=n123
XU261 CKND2D0BWP7T $PINS A1=n327 A2=n328 ZN=n20
XU262 AOI22D0BWP7T $PINS A1=n77 A2=n81 B1=n29 B2=n47 ZN=n318
XU263 AOI22D0BWP7T $PINS A1=n36 A2=n56 B1=n31 B2=n114 ZN=n317
XU264 CKND0BWP7T $PINS I=n12 ZN=n114
XU265 CKND0BWP7T $PINS I=n95 ZN=n31
XU266 CKND0BWP7T $PINS I=n127 ZN=n36
XU267 ND4D0BWP7T $PINS A1=n329 A2=n330 A3=n331 A4=n332 ZN=n148
XU268 AOI211D0BWP7T $PINS A1=n81 A2=n301 B=n333 C=n334 ZN=n332
XU269 AOI21D0BWP7T $PINS A1=n12 A2=n94 B=n40 ZN=n334
XU270 CKND2D0BWP7T $PINS A1=n316 A2=n335 ZN=n12
XU271 AOI21D0BWP7T $PINS A1=n60 A2=n61 B=n141 ZN=n333
XU272 CKND2D0BWP7T $PINS A1=n336 A2=n327 ZN=n60
XU273 CKND2D0BWP7T $PINS A1=n9 A2=n126 ZN=n301
XU274 CKND0BWP7T $PINS I=n41 ZN=n81
XU275 CKND2D0BWP7T $PINS A1=n337 A2=n328 ZN=n41
XU276 MAOI22D0BWP7T $PINS A1=n47 A2=n111 B1=n61 B2=n23 ZN=n331
XU277 NR2D0BWP7T $PINS A1=n80 A2=n29 ZN=n23
XU278 CKND0BWP7T $PINS I=n45 ZN=n29
XU279 CKND2D0BWP7T $PINS A1=n338 A2=n339 ZN=n45
XU280 CKND2D0BWP7T $PINS A1=n9 A2=n141 ZN=n111
XU281 CKND0BWP7T $PINS I=n14 ZN=n47
XU282 CKND2D0BWP7T $PINS A1=n340 A2=n326 ZN=n14
XU283 AOI222D0BWP7T $PINS A1=n28 A2=n54 B1=n77 B2=n96 C1=n57 C2=n128 ZN=n330
XU284 CKND0BWP7T $PINS I=n24 ZN=n57
XU285 CKND2D0BWP7T $PINS A1=n95 A2=n74 ZN=n96
XU286 CKND2D0BWP7T $PINS A1=n341 A2=n337 ZN=n95
XU287 CKND0BWP7T $PINS I=n140 ZN=n54
XU288 CKND2D0BWP7T $PINS A1=n315 A2=n338 ZN=n140
XU289 AOI22D0BWP7T $PINS A1=n75 A2=n49 B1=n30 B2=n131 ZN=n329
XU290 CKND0BWP7T $PINS I=n98 ZN=n131
XU291 CKND0BWP7T $PINS I=n155 ZN=n30
XU292 CKND2D0BWP7T $PINS A1=n339 A2=n342 ZN=n155
XU293 CKND0BWP7T $PINS I=n74 ZN=n49
XU294 CKND2D0BWP7T $PINS A1=n336 A2=n337 ZN=n74
XU295 CKND0BWP7T $PINS I=n62 ZN=n75
XU296 CKND2D0BWP7T $PINS A1=n335 A2=n342 ZN=n62
XU297 ND4D0BWP7T $PINS A1=n343 A2=n344 A3=n345 A4=n346 ZN=n147
XU298 AOI221D0BWP7T $PINS A1=n80 A2=n115 B1=n84 B2=n130 C=n347 ZN=n346
XU299 AOI21D0BWP7T $PINS A1=n42 A2=n127 B=n10 ZN=n347
XU300 CKND2D0BWP7T $PINS A1=n341 A2=n340 ZN=n127
XU301 NR2D0BWP7T $PINS A1=n237 A2=n28 ZN=n42
XU302 CKND0BWP7T $PINS I=n52 ZN=n28
XU303 CKND2D0BWP7T $PINS A1=n336 A2=n340 ZN=n52
XU304 CKND0BWP7T $PINS I=n93 ZN=n130
XU305 NR2D0BWP7T $PINS A1=n46 A2=n48 ZN=n93
XU306 CKND0BWP7T $PINS I=n10 ZN=n46
XU307 CKND2D0BWP7T $PINS A1=n338 A2=n335 ZN=n10
XU308 CKND0BWP7T $PINS I=n40 ZN=n84
XU309 CKND2D0BWP7T $PINS A1=n336 A2=n348 ZN=n40
XU310 NR2D0BWP7T $PINS A1=n349 A2=a[6] ZN=n336
XU311 CKND0BWP7T $PINS I=n200 ZN=n115
XU312 CKND2D0BWP7T $PINS A1=n326 A2=n337 ZN=n200
XU313 NR2D0BWP7T $PINS A1=n350 A2=a[4] ZN=n337
XU314 CKND0BWP7T $PINS I=n9 ZN=n80
XU315 CKND2D0BWP7T $PINS A1=n316 A2=n339 ZN=n9
XU316 IOA21D0BWP7T $PINS A1=n19 A2=n112 B=n237 ZN=n345
XU317 CKND0BWP7T $PINS I=n18 ZN=n237
XU318 CKND2D0BWP7T $PINS A1=n348 A2=n328 ZN=n18
XU319 NR2D0BWP7T $PINS A1=n82 A2=n128 ZN=n112
XU320 CKND0BWP7T $PINS I=n22 ZN=n128
XU321 CKND2D0BWP7T $PINS A1=n324 A2=n335 ZN=n22
XU322 NR2D0BWP7T $PINS A1=n351 A2=n352 ZN=n335
XU323 CKND0BWP7T $PINS I=n51 ZN=n82
XU324 CKND2D0BWP7T $PINS A1=n324 A2=n315 ZN=n51
XU325 NR2D0BWP7T $PINS A1=n132 A2=n77 ZN=n19
XU326 CKND0BWP7T $PINS I=n94 ZN=n77
XU327 CKND2D0BWP7T $PINS A1=n324 A2=n339 ZN=n94
XU328 NR2D0BWP7T $PINS A1=n352 A2=a[3] ZN=n339
XU329 CKND0BWP7T $PINS I=a[2] ZN=n352
XU330 NR2D0BWP7T $PINS A1=a[1] A2=a[0] ZN=n324
XU331 CKND0BWP7T $PINS I=n59 ZN=n132
XU332 CKND2D0BWP7T $PINS A1=n316 A2=n325 ZN=n59
XU333 NR2D0BWP7T $PINS A1=n353 A2=a[1] ZN=n316
XU334 OAI21D0BWP7T $PINS A1=n56 A2=n170 B=n79 ZN=n344
XU335 CKND0BWP7T $PINS I=n53 ZN=n79
XU336 CKND0BWP7T $PINS I=n141 ZN=n170
XU337 CKND2D0BWP7T $PINS A1=n315 A2=n342 ZN=n141
XU338 NR2D0BWP7T $PINS A1=a[3] A2=a[2] ZN=n315
XU339 CKND0BWP7T $PINS I=n16 ZN=n56
XU340 CKND2D0BWP7T $PINS A1=n325 A2=n338 ZN=n16
XU341 NR2D0BWP7T $PINS A1=n354 A2=a[0] ZN=n338
XU342 IOA21D0BWP7T $PINS A1=n98 A2=n308 B=n48 ZN=n343
XU343 CKND0BWP7T $PINS I=n126 ZN=n48
XU344 CKND2D0BWP7T $PINS A1=n325 A2=n342 ZN=n126
XU345 NR2D0BWP7T $PINS A1=n354 A2=n353 ZN=n342
XU346 CKND0BWP7T $PINS I=a[0] ZN=n353
XU347 CKND0BWP7T $PINS I=a[1] ZN=n354
XU348 NR2D0BWP7T $PINS A1=n351 A2=a[2] ZN=n325
XU349 CKND0BWP7T $PINS I=a[3] ZN=n351
XU350 NR2D0BWP7T $PINS A1=n179 A2=n78 ZN=n308
XU351 CKND0BWP7T $PINS I=n61 ZN=n78
XU352 CKND2D0BWP7T $PINS A1=n348 A2=n326 ZN=n61
XU353 NR2D0BWP7T $PINS A1=a[7] A2=a[6] ZN=n326
XU354 CKND2D0BWP7T $PINS A1=n24 A2=n53 ZN=n179
XU355 CKND2D0BWP7T $PINS A1=n341 A2=n327 ZN=n53
XU356 NR2D0BWP7T $PINS A1=n350 A2=n355 ZN=n327
XU357 CKND0BWP7T $PINS I=a[5] ZN=n350
XU358 CKND2D0BWP7T $PINS A1=n341 A2=n348 ZN=n24
XU359 NR2D0BWP7T $PINS A1=a[5] A2=a[4] ZN=n348
XU360 NR2D0BWP7T $PINS A1=n349 A2=n356 ZN=n341
XU361 CKND0BWP7T $PINS I=a[7] ZN=n349
XU362 CKND2D0BWP7T $PINS A1=n340 A2=n328 ZN=n98
XU363 NR2D0BWP7T $PINS A1=n356 A2=a[7] ZN=n328
XU364 CKND0BWP7T $PINS I=a[6] ZN=n356
XU365 NR2D0BWP7T $PINS A1=n355 A2=a[5] ZN=n340
XU366 CKND0BWP7T $PINS I=a[4] ZN=n355
.ENDS

.SUBCKT aes_cipher_top clk rst ld done key[127] key[126] key[125] key[124]
+ key[123] key[122] key[121] key[120] key[119] key[118] key[117] key[116]
+ key[115] key[114] key[113] key[112] key[111] key[110] key[109] key[108]
+ key[107] key[106] key[105] key[104] key[103] key[102] key[101] key[100]
+ key[99] key[98] key[97] key[96] key[95] key[94] key[93] key[92] key[91]
+ key[90] key[89] key[88] key[87] key[86] key[85] key[84] key[83] key[82]
+ key[81] key[80] key[79] key[78] key[77] key[76] key[75] key[74] key[73]
+ key[72] key[71] key[70] key[69] key[68] key[67] key[66] key[65] key[64]
+ key[63] key[62] key[61] key[60] key[59] key[58] key[57] key[56] key[55]
+ key[54] key[53] key[52] key[51] key[50] key[49] key[48] key[47] key[46]
+ key[45] key[44] key[43] key[42] key[41] key[40] key[39] key[38] key[37]
+ key[36] key[35] key[34] key[33] key[32] key[31] key[30] key[29] key[28]
+ key[27] key[26] key[25] key[24] key[23] key[22] key[21] key[20] key[19]
+ key[18] key[17] key[16] key[15] key[14] key[13] key[12] key[11] key[10]
+ key[9] key[8] key[7] key[6] key[5] key[4] key[3] key[2] key[1] key[0]
+ text_in[127] text_in[126] text_in[125] text_in[124] text_in[123] text_in[122]
+ text_in[121] text_in[120] text_in[119] text_in[118] text_in[117] text_in[116]
+ text_in[115] text_in[114] text_in[113] text_in[112] text_in[111] text_in[110]
+ text_in[109] text_in[108] text_in[107] text_in[106] text_in[105] text_in[104]
+ text_in[103] text_in[102] text_in[101] text_in[100] text_in[99] text_in[98]
+ text_in[97] text_in[96] text_in[95] text_in[94] text_in[93] text_in[92]
+ text_in[91] text_in[90] text_in[89] text_in[88] text_in[87] text_in[86]
+ text_in[85] text_in[84] text_in[83] text_in[82] text_in[81] text_in[80]
+ text_in[79] text_in[78] text_in[77] text_in[76] text_in[75] text_in[74]
+ text_in[73] text_in[72] text_in[71] text_in[70] text_in[69] text_in[68]
+ text_in[67] text_in[66] text_in[65] text_in[64] text_in[63] text_in[62]
+ text_in[61] text_in[60] text_in[59] text_in[58] text_in[57] text_in[56]
+ text_in[55] text_in[54] text_in[53] text_in[52] text_in[51] text_in[50]
+ text_in[49] text_in[48] text_in[47] text_in[46] text_in[45] text_in[44]
+ text_in[43] text_in[42] text_in[41] text_in[40] text_in[39] text_in[38]
+ text_in[37] text_in[36] text_in[35] text_in[34] text_in[33] text_in[32]
+ text_in[31] text_in[30] text_in[29] text_in[28] text_in[27] text_in[26]
+ text_in[25] text_in[24] text_in[23] text_in[22] text_in[21] text_in[20]
+ text_in[19] text_in[18] text_in[17] text_in[16] text_in[15] text_in[14]
+ text_in[13] text_in[12] text_in[11] text_in[10] text_in[9] text_in[8]
+ text_in[7] text_in[6] text_in[5] text_in[4] text_in[3] text_in[2] text_in[1]
+ text_in[0] text_out[127] text_out[126] text_out[125] text_out[124]
+ text_out[123] text_out[122] text_out[121] text_out[120] text_out[119]
+ text_out[118] text_out[117] text_out[116] text_out[115] text_out[114]
+ text_out[113] text_out[112] text_out[111] text_out[110] text_out[109]
+ text_out[108] text_out[107] text_out[106] text_out[105] text_out[104]
+ text_out[103] text_out[102] text_out[101] text_out[100] text_out[99]
+ text_out[98] text_out[97] text_out[96] text_out[95] text_out[94] text_out[93]
+ text_out[92] text_out[91] text_out[90] text_out[89] text_out[88] text_out[87]
+ text_out[86] text_out[85] text_out[84] text_out[83] text_out[82] text_out[81]
+ text_out[80] text_out[79] text_out[78] text_out[77] text_out[76] text_out[75]
+ text_out[74] text_out[73] text_out[72] text_out[71] text_out[70] text_out[69]
+ text_out[68] text_out[67] text_out[66] text_out[65] text_out[64] text_out[63]
+ text_out[62] text_out[61] text_out[60] text_out[59] text_out[58] text_out[57]
+ text_out[56] text_out[55] text_out[54] text_out[53] text_out[52] text_out[51]
+ text_out[50] text_out[49] text_out[48] text_out[47] text_out[46] text_out[45]
+ text_out[44] text_out[43] text_out[42] text_out[41] text_out[40] text_out[39]
+ text_out[38] text_out[37] text_out[36] text_out[35] text_out[34] text_out[33]
+ text_out[32] text_out[31] text_out[30] text_out[29] text_out[28] text_out[27]
+ text_out[26] text_out[25] text_out[24] text_out[23] text_out[22] text_out[21]
+ text_out[20] text_out[19] text_out[18] text_out[17] text_out[16] text_out[15]
+ text_out[14] text_out[13] text_out[12] text_out[11] text_out[10] text_out[9]
+ text_out[8] text_out[7] text_out[6] text_out[5] text_out[4] text_out[3]
+ text_out[2] text_out[1] text_out[0]
Xu0 aes_key_expand_128 $PINS krst=rst clk=clk kld=ld key[127]=key[127]
+ key[126]=key[126] key[125]=key[125] key[124]=key[124] key[123]=key[123]
+ key[122]=key[122] key[121]=key[121] key[120]=key[120] key[119]=key[119]
+ key[118]=key[118] key[117]=key[117] key[116]=key[116] key[115]=key[115]
+ key[114]=key[114] key[113]=key[113] key[112]=key[112] key[111]=key[111]
+ key[110]=key[110] key[109]=key[109] key[108]=key[108] key[107]=key[107]
+ key[106]=key[106] key[105]=key[105] key[104]=key[104] key[103]=key[103]
+ key[102]=key[102] key[101]=key[101] key[100]=key[100] key[99]=key[99]
+ key[98]=key[98] key[97]=key[97] key[96]=key[96] key[95]=key[95] key[94]=key[94]
+ key[93]=key[93] key[92]=key[92] key[91]=key[91] key[90]=key[90] key[89]=key[89]
+ key[88]=key[88] key[87]=key[87] key[86]=key[86] key[85]=key[85] key[84]=key[84]
+ key[83]=key[83] key[82]=key[82] key[81]=key[81] key[80]=key[80] key[79]=key[79]
+ key[78]=key[78] key[77]=key[77] key[76]=key[76] key[75]=key[75] key[74]=key[74]
+ key[73]=key[73] key[72]=key[72] key[71]=key[71] key[70]=key[70] key[69]=key[69]
+ key[68]=key[68] key[67]=key[67] key[66]=key[66] key[65]=key[65] key[64]=key[64]
+ key[63]=key[63] key[62]=key[62] key[61]=key[61] key[60]=key[60] key[59]=key[59]
+ key[58]=key[58] key[57]=key[57] key[56]=key[56] key[55]=key[55] key[54]=key[54]
+ key[53]=key[53] key[52]=key[52] key[51]=key[51] key[50]=key[50] key[49]=key[49]
+ key[48]=key[48] key[47]=key[47] key[46]=key[46] key[45]=key[45] key[44]=key[44]
+ key[43]=key[43] key[42]=key[42] key[41]=key[41] key[40]=key[40] key[39]=key[39]
+ key[38]=key[38] key[37]=key[37] key[36]=key[36] key[35]=key[35] key[34]=key[34]
+ key[33]=key[33] key[32]=key[32] key[31]=key[31] key[30]=key[30] key[29]=key[29]
+ key[28]=key[28] key[27]=key[27] key[26]=key[26] key[25]=key[25] key[24]=key[24]
+ key[23]=key[23] key[22]=key[22] key[21]=key[21] key[20]=key[20] key[19]=key[19]
+ key[18]=key[18] key[17]=key[17] key[16]=key[16] key[15]=key[15] key[14]=key[14]
+ key[13]=key[13] key[12]=key[12] key[11]=key[11] key[10]=key[10] key[9]=key[9]
+ key[8]=key[8] key[7]=key[7] key[6]=key[6] key[5]=key[5] key[4]=key[4]
+ key[3]=key[3] key[2]=key[2] key[1]=key[1] key[0]=key[0] wo_0[31]=w0[31]
+ wo_0[30]=w0[30] wo_0[29]=w0[29] wo_0[28]=w0[28] wo_0[27]=w0[27] wo_0[26]=w0[26]
+ wo_0[25]=w0[25] wo_0[24]=w0[24] wo_0[23]=w0[23] wo_0[22]=w0[22] wo_0[21]=w0[21]
+ wo_0[20]=w0[20] wo_0[19]=w0[19] wo_0[18]=w0[18] wo_0[17]=w0[17] wo_0[16]=w0[16]
+ wo_0[15]=w0[15] wo_0[14]=w0[14] wo_0[13]=w0[13] wo_0[12]=w0[12] wo_0[11]=w0[11]
+ wo_0[10]=w0[10] wo_0[9]=w0[9] wo_0[8]=w0[8] wo_0[7]=w0[7] wo_0[6]=w0[6]
+ wo_0[5]=w0[5] wo_0[4]=w0[4] wo_0[3]=w0[3] wo_0[2]=w0[2] wo_0[1]=w0[1]
+ wo_0[0]=w0[0] wo_1[31]=w1[31] wo_1[30]=w1[30] wo_1[29]=w1[29] wo_1[28]=w1[28]
+ wo_1[27]=w1[27] wo_1[26]=w1[26] wo_1[25]=w1[25] wo_1[24]=w1[24] wo_1[23]=w1[23]
+ wo_1[22]=w1[22] wo_1[21]=w1[21] wo_1[20]=w1[20] wo_1[19]=w1[19] wo_1[18]=w1[18]
+ wo_1[17]=w1[17] wo_1[16]=w1[16] wo_1[15]=w1[15] wo_1[14]=w1[14] wo_1[13]=w1[13]
+ wo_1[12]=w1[12] wo_1[11]=w1[11] wo_1[10]=w1[10] wo_1[9]=w1[9] wo_1[8]=w1[8]
+ wo_1[7]=w1[7] wo_1[6]=w1[6] wo_1[5]=w1[5] wo_1[4]=w1[4] wo_1[3]=w1[3]
+ wo_1[2]=w1[2] wo_1[1]=w1[1] wo_1[0]=w1[0] wo_2[31]=w2[31] wo_2[30]=w2[30]
+ wo_2[29]=w2[29] wo_2[28]=w2[28] wo_2[27]=w2[27] wo_2[26]=w2[26] wo_2[25]=w2[25]
+ wo_2[24]=w2[24] wo_2[23]=w2[23] wo_2[22]=w2[22] wo_2[21]=w2[21] wo_2[20]=w2[20]
+ wo_2[19]=w2[19] wo_2[18]=w2[18] wo_2[17]=w2[17] wo_2[16]=w2[16] wo_2[15]=w2[15]
+ wo_2[14]=w2[14] wo_2[13]=w2[13] wo_2[12]=w2[12] wo_2[11]=w2[11] wo_2[10]=w2[10]
+ wo_2[9]=w2[9] wo_2[8]=w2[8] wo_2[7]=w2[7] wo_2[6]=w2[6] wo_2[5]=w2[5]
+ wo_2[4]=w2[4] wo_2[3]=w2[3] wo_2[2]=w2[2] wo_2[1]=w2[1] wo_2[0]=w2[0]
+ wo_3[31]=w3[31] wo_3[30]=w3[30] wo_3[29]=w3[29] wo_3[28]=w3[28] wo_3[27]=w3[27]
+ wo_3[26]=w3[26] wo_3[25]=w3[25] wo_3[24]=w3[24] wo_3[23]=w3[23] wo_3[22]=w3[22]
+ wo_3[21]=w3[21] wo_3[20]=w3[20] wo_3[19]=w3[19] wo_3[18]=w3[18] wo_3[17]=w3[17]
+ wo_3[16]=w3[16] wo_3[15]=w3[15] wo_3[14]=w3[14] wo_3[13]=w3[13] wo_3[12]=w3[12]
+ wo_3[11]=w3[11] wo_3[10]=w3[10] wo_3[9]=w3[9] wo_3[8]=w3[8] wo_3[7]=w3[7]
+ wo_3[6]=w3[6] wo_3[5]=w3[5] wo_3[4]=w3[4] wo_3[3]=w3[3] wo_3[2]=w3[2]
+ wo_3[1]=w3[1] wo_3[0]=w3[0]
Xus00 aes_sbox_0 $PINS a[7]=sa00[7] a[6]=sa00[6] a[5]=sa00[5] a[4]=sa00[4]
+ a[3]=sa00[3] a[2]=sa00[2] a[1]=sa00[1] a[0]=sa00[0] d[7]=sa00_sr[7]
+ d[6]=sa00_sr[6] d[5]=sa00_sr[5] d[4]=sa00_sr[4] d[3]=sa00_sr[3] d[2]=sa00_sr[2]
+ d[1]=sa00_sr[1] d[0]=sa00_sr[0]
Xus01 aes_sbox_19 $PINS a[7]=sa01[7] a[6]=sa01[6] a[5]=sa01[5] a[4]=sa01[4]
+ a[3]=sa01[3] a[2]=sa01[2] a[1]=sa01[1] a[0]=sa01[0] d[7]=sa01_sr[7]
+ d[6]=sa01_sr[6] d[5]=sa01_sr[5] d[4]=sa01_sr[4] d[3]=sa01_sr[3] d[2]=sa01_sr[2]
+ d[1]=sa01_sr[1] d[0]=sa01_sr[0]
Xus02 aes_sbox_18 $PINS a[7]=sa02[7] a[6]=sa02[6] a[5]=sa02[5] a[4]=sa02[4]
+ a[3]=sa02[3] a[2]=sa02[2] a[1]=sa02[1] a[0]=sa02[0] d[7]=sa02_sr[7]
+ d[6]=sa02_sr[6] d[5]=sa02_sr[5] d[4]=sa02_sr[4] d[3]=sa02_sr[3] d[2]=sa02_sr[2]
+ d[1]=sa02_sr[1] d[0]=sa02_sr[0]
Xus03 aes_sbox_17 $PINS a[7]=sa03[7] a[6]=sa03[6] a[5]=sa03[5] a[4]=sa03[4]
+ a[3]=sa03[3] a[2]=sa03[2] a[1]=sa03[1] a[0]=sa03[0] d[7]=sa03_sr[7]
+ d[6]=sa03_sr[6] d[5]=sa03_sr[5] d[4]=sa03_sr[4] d[3]=sa03_sr[3] d[2]=sa03_sr[2]
+ d[1]=sa03_sr[1] d[0]=sa03_sr[0]
Xus10 aes_sbox_16 $PINS a[7]=sa10[7] a[6]=sa10[6] a[5]=sa10[5] a[4]=sa10[4]
+ a[3]=sa10[3] a[2]=sa10[2] a[1]=sa10[1] a[0]=sa10[0] d[7]=sa13_sr[7]
+ d[6]=sa13_sr[6] d[5]=sa13_sr[5] d[4]=sa13_sr[4] d[3]=sa13_sr[3] d[2]=sa13_sr[2]
+ d[1]=sa13_sr[1] d[0]=sa13_sr[0]
Xus11 aes_sbox_15 $PINS a[7]=sa11[7] a[6]=sa11[6] a[5]=sa11[5] a[4]=sa11[4]
+ a[3]=sa11[3] a[2]=sa11[2] a[1]=sa11[1] a[0]=sa11[0] d[7]=sa10_sr[7]
+ d[6]=sa10_sr[6] d[5]=sa10_sr[5] d[4]=sa10_sr[4] d[3]=sa10_sr[3] d[2]=sa10_sr[2]
+ d[1]=sa10_sr[1] d[0]=sa10_sr[0]
Xus12 aes_sbox_14 $PINS a[7]=sa12[7] a[6]=sa12[6] a[5]=sa12[5] a[4]=sa12[4]
+ a[3]=sa12[3] a[2]=sa12[2] a[1]=sa12[1] a[0]=sa12[0] d[7]=sa11_sr[7]
+ d[6]=sa11_sr[6] d[5]=sa11_sr[5] d[4]=sa11_sr[4] d[3]=sa11_sr[3] d[2]=sa11_sr[2]
+ d[1]=sa11_sr[1] d[0]=sa11_sr[0]
Xus13 aes_sbox_13 $PINS a[7]=sa13[7] a[6]=sa13[6] a[5]=sa13[5] a[4]=sa13[4]
+ a[3]=sa13[3] a[2]=sa13[2] a[1]=sa13[1] a[0]=sa13[0] d[7]=sa12_sr[7]
+ d[6]=sa12_sr[6] d[5]=sa12_sr[5] d[4]=sa12_sr[4] d[3]=sa12_sr[3] d[2]=sa12_sr[2]
+ d[1]=sa12_sr[1] d[0]=sa12_sr[0]
Xus20 aes_sbox_12 $PINS a[7]=sa20[7] a[6]=sa20[6] a[5]=sa20[5] a[4]=sa20[4]
+ a[3]=sa20[3] a[2]=sa20[2] a[1]=sa20[1] a[0]=sa20[0] d[7]=sa22_sr[7]
+ d[6]=sa22_sr[6] d[5]=sa22_sr[5] d[4]=sa22_sr[4] d[3]=sa22_sr[3] d[2]=sa22_sr[2]
+ d[1]=sa22_sr[1] d[0]=sa22_sr[0]
Xus21 aes_sbox_11 $PINS a[7]=sa21[7] a[6]=sa21[6] a[5]=sa21[5] a[4]=sa21[4]
+ a[3]=sa21[3] a[2]=sa21[2] a[1]=sa21[1] a[0]=sa21[0] d[7]=sa23_sr[7]
+ d[6]=sa23_sr[6] d[5]=sa23_sr[5] d[4]=sa23_sr[4] d[3]=sa23_sr[3] d[2]=sa23_sr[2]
+ d[1]=sa23_sr[1] d[0]=sa23_sr[0]
Xus22 aes_sbox_10 $PINS a[7]=sa22[7] a[6]=sa22[6] a[5]=sa22[5] a[4]=sa22[4]
+ a[3]=sa22[3] a[2]=sa22[2] a[1]=sa22[1] a[0]=sa22[0] d[7]=sa20_sr[7]
+ d[6]=sa20_sr[6] d[5]=sa20_sr[5] d[4]=sa20_sr[4] d[3]=sa20_sr[3] d[2]=sa20_sr[2]
+ d[1]=sa20_sr[1] d[0]=sa20_sr[0]
Xus23 aes_sbox_9 $PINS a[7]=sa23[7] a[6]=sa23[6] a[5]=sa23[5] a[4]=sa23[4]
+ a[3]=sa23[3] a[2]=sa23[2] a[1]=sa23[1] a[0]=sa23[0] d[7]=sa21_sr[7]
+ d[6]=sa21_sr[6] d[5]=sa21_sr[5] d[4]=sa21_sr[4] d[3]=sa21_sr[3] d[2]=sa21_sr[2]
+ d[1]=sa21_sr[1] d[0]=sa21_sr[0]
Xus30 aes_sbox_8 $PINS a[7]=sa30[7] a[6]=sa30[6] a[5]=sa30[5] a[4]=sa30[4]
+ a[3]=sa30[3] a[2]=sa30[2] a[1]=sa30[1] a[0]=sa30[0] d[7]=sa31_sr[7]
+ d[6]=sa31_sr[6] d[5]=sa31_sr[5] d[4]=sa31_sr[4] d[3]=sa31_sr[3] d[2]=sa31_sr[2]
+ d[1]=sa31_sr[1] d[0]=sa31_sr[0]
Xus31 aes_sbox_7 $PINS a[7]=sa31[7] a[6]=sa31[6] a[5]=sa31[5] a[4]=sa31[4]
+ a[3]=sa31[3] a[2]=sa31[2] a[1]=sa31[1] a[0]=sa31[0] d[7]=sa32_sr[7]
+ d[6]=sa32_sr[6] d[5]=sa32_sr[5] d[4]=sa32_sr[4] d[3]=sa32_sr[3] d[2]=sa32_sr[2]
+ d[1]=sa32_sr[1] d[0]=sa32_sr[0]
Xus32 aes_sbox_6 $PINS a[7]=sa32[7] a[6]=sa32[6] a[5]=sa32[5] a[4]=sa32[4]
+ a[3]=sa32[3] a[2]=sa32[2] a[1]=sa32[1] a[0]=sa32[0] d[7]=sa33_sr[7]
+ d[6]=sa33_sr[6] d[5]=sa33_sr[5] d[4]=sa33_sr[4] d[3]=sa33_sr[3] d[2]=sa33_sr[2]
+ d[1]=sa33_sr[1] d[0]=sa33_sr[0]
Xus33 aes_sbox_5 $PINS a[7]=sa33[7] a[6]=sa33[6] a[5]=sa33[5] a[4]=sa33[4]
+ a[3]=sa33[3] a[2]=sa33[2] a[1]=sa33[1] a[0]=sa33[0] d[7]=sa30_sr[7]
+ d[6]=sa30_sr[6] d[5]=sa30_sr[5] d[4]=sa30_sr[4] d[3]=sa30_sr[3] d[2]=sa30_sr[2]
+ d[1]=sa30_sr[1] d[0]=sa30_sr[0]
Xdone_reg DFQD0BWP7T $PINS D=N22 CP=clk Q=done
Xtext_in_r_reg[127] EDFCNQD1BWP7T $PINS D=text_in[127] E=ld CP=clk CDN=rst
+ Q=text_in_r[127]
Xtext_in_r_reg[126] EDFCNQD1BWP7T $PINS D=text_in[126] E=ld CP=clk CDN=rst
+ Q=text_in_r[126]
Xtext_in_r_reg[125] EDFCNQD1BWP7T $PINS D=text_in[125] E=ld CP=clk CDN=rst
+ Q=text_in_r[125]
Xtext_in_r_reg[124] EDFCNQD1BWP7T $PINS D=text_in[124] E=ld CP=clk CDN=rst
+ Q=text_in_r[124]
Xtext_in_r_reg[123] EDFCNQD1BWP7T $PINS D=text_in[123] E=ld CP=clk CDN=rst
+ Q=text_in_r[123]
Xtext_in_r_reg[122] EDFCNQD1BWP7T $PINS D=text_in[122] E=ld CP=clk CDN=rst
+ Q=text_in_r[122]
Xtext_in_r_reg[121] EDFCNQD1BWP7T $PINS D=text_in[121] E=ld CP=clk CDN=rst
+ Q=text_in_r[121]
Xtext_in_r_reg[120] EDFCNQD1BWP7T $PINS D=text_in[120] E=ld CP=clk CDN=rst
+ Q=text_in_r[120]
Xtext_in_r_reg[119] EDFCNQD1BWP7T $PINS D=text_in[119] E=ld CP=clk CDN=rst
+ Q=text_in_r[119]
Xtext_in_r_reg[118] EDFCNQD1BWP7T $PINS D=text_in[118] E=ld CP=clk CDN=rst
+ Q=text_in_r[118]
Xtext_in_r_reg[117] EDFCNQD1BWP7T $PINS D=text_in[117] E=ld CP=clk CDN=rst
+ Q=text_in_r[117]
Xtext_in_r_reg[116] EDFCNQD1BWP7T $PINS D=text_in[116] E=ld CP=clk CDN=rst
+ Q=text_in_r[116]
Xtext_in_r_reg[115] EDFCNQD1BWP7T $PINS D=text_in[115] E=ld CP=clk CDN=rst
+ Q=text_in_r[115]
Xtext_in_r_reg[114] EDFCNQD1BWP7T $PINS D=text_in[114] E=ld CP=clk CDN=rst
+ Q=text_in_r[114]
Xtext_in_r_reg[113] EDFCNQD1BWP7T $PINS D=text_in[113] E=ld CP=clk CDN=rst
+ Q=text_in_r[113]
Xtext_in_r_reg[112] EDFCNQD1BWP7T $PINS D=text_in[112] E=ld CP=clk CDN=rst
+ Q=text_in_r[112]
Xtext_in_r_reg[111] EDFCNQD1BWP7T $PINS D=text_in[111] E=ld CP=clk CDN=rst
+ Q=text_in_r[111]
Xtext_in_r_reg[110] EDFCNQD1BWP7T $PINS D=text_in[110] E=ld CP=clk CDN=rst
+ Q=text_in_r[110]
Xtext_in_r_reg[109] EDFCNQD1BWP7T $PINS D=text_in[109] E=ld CP=clk CDN=rst
+ Q=text_in_r[109]
Xtext_in_r_reg[108] EDFCNQD1BWP7T $PINS D=text_in[108] E=ld CP=clk CDN=rst
+ Q=text_in_r[108]
Xtext_in_r_reg[107] EDFCNQD1BWP7T $PINS D=text_in[107] E=ld CP=clk CDN=rst
+ Q=text_in_r[107]
Xtext_in_r_reg[106] EDFCNQD1BWP7T $PINS D=text_in[106] E=ld CP=clk CDN=rst
+ Q=text_in_r[106]
Xtext_in_r_reg[105] EDFCNQD1BWP7T $PINS D=text_in[105] E=ld CP=clk CDN=rst
+ Q=text_in_r[105]
Xtext_in_r_reg[104] EDFCNQD1BWP7T $PINS D=text_in[104] E=ld CP=clk CDN=rst
+ Q=text_in_r[104]
Xtext_in_r_reg[103] EDFCNQD1BWP7T $PINS D=text_in[103] E=ld CP=clk CDN=rst
+ Q=text_in_r[103]
Xtext_in_r_reg[102] EDFCNQD1BWP7T $PINS D=text_in[102] E=ld CP=clk CDN=rst
+ Q=text_in_r[102]
Xtext_in_r_reg[101] EDFCNQD1BWP7T $PINS D=text_in[101] E=ld CP=clk CDN=rst
+ Q=text_in_r[101]
Xtext_in_r_reg[100] EDFCNQD1BWP7T $PINS D=text_in[100] E=ld CP=clk CDN=rst
+ Q=text_in_r[100]
Xtext_in_r_reg[99] EDFCNQD1BWP7T $PINS D=text_in[99] E=ld CP=clk CDN=rst
+ Q=text_in_r[99]
Xtext_in_r_reg[98] EDFCNQD1BWP7T $PINS D=text_in[98] E=ld CP=clk CDN=rst
+ Q=text_in_r[98]
Xtext_in_r_reg[97] EDFCNQD1BWP7T $PINS D=text_in[97] E=ld CP=clk CDN=rst
+ Q=text_in_r[97]
Xtext_in_r_reg[96] EDFCNQD1BWP7T $PINS D=text_in[96] E=ld CP=clk CDN=rst
+ Q=text_in_r[96]
Xtext_in_r_reg[95] EDFCNQD1BWP7T $PINS D=text_in[95] E=ld CP=clk CDN=rst
+ Q=text_in_r[95]
Xtext_in_r_reg[94] EDFCNQD1BWP7T $PINS D=text_in[94] E=ld CP=clk CDN=rst
+ Q=text_in_r[94]
Xtext_in_r_reg[93] EDFCNQD1BWP7T $PINS D=text_in[93] E=ld CP=clk CDN=rst
+ Q=text_in_r[93]
Xtext_in_r_reg[92] EDFCNQD1BWP7T $PINS D=text_in[92] E=ld CP=clk CDN=rst
+ Q=text_in_r[92]
Xtext_in_r_reg[91] EDFCNQD1BWP7T $PINS D=text_in[91] E=ld CP=clk CDN=rst
+ Q=text_in_r[91]
Xtext_in_r_reg[90] EDFCNQD1BWP7T $PINS D=text_in[90] E=ld CP=clk CDN=rst
+ Q=text_in_r[90]
Xtext_in_r_reg[89] EDFCNQD1BWP7T $PINS D=text_in[89] E=ld CP=clk CDN=rst
+ Q=text_in_r[89]
Xtext_in_r_reg[88] EDFCNQD1BWP7T $PINS D=text_in[88] E=ld CP=clk CDN=rst
+ Q=text_in_r[88]
Xtext_in_r_reg[87] EDFCNQD1BWP7T $PINS D=text_in[87] E=ld CP=clk CDN=rst
+ Q=text_in_r[87]
Xtext_in_r_reg[86] EDFCNQD1BWP7T $PINS D=text_in[86] E=ld CP=clk CDN=rst
+ Q=text_in_r[86]
Xtext_in_r_reg[85] EDFCNQD1BWP7T $PINS D=text_in[85] E=ld CP=clk CDN=rst
+ Q=text_in_r[85]
Xtext_in_r_reg[84] EDFCNQD1BWP7T $PINS D=text_in[84] E=ld CP=clk CDN=rst
+ Q=text_in_r[84]
Xtext_in_r_reg[83] EDFCNQD1BWP7T $PINS D=text_in[83] E=ld CP=clk CDN=rst
+ Q=text_in_r[83]
Xtext_in_r_reg[82] EDFCNQD1BWP7T $PINS D=text_in[82] E=ld CP=clk CDN=rst
+ Q=text_in_r[82]
Xtext_in_r_reg[81] EDFCNQD1BWP7T $PINS D=text_in[81] E=ld CP=clk CDN=rst
+ Q=text_in_r[81]
Xtext_in_r_reg[80] EDFCNQD1BWP7T $PINS D=text_in[80] E=ld CP=clk CDN=rst
+ Q=text_in_r[80]
Xtext_in_r_reg[79] EDFCNQD1BWP7T $PINS D=text_in[79] E=ld CP=clk CDN=rst
+ Q=text_in_r[79]
Xtext_in_r_reg[78] EDFCNQD1BWP7T $PINS D=text_in[78] E=ld CP=clk CDN=rst
+ Q=text_in_r[78]
Xtext_in_r_reg[77] EDFCNQD1BWP7T $PINS D=text_in[77] E=ld CP=clk CDN=rst
+ Q=text_in_r[77]
Xtext_in_r_reg[76] EDFCNQD1BWP7T $PINS D=text_in[76] E=ld CP=clk CDN=rst
+ Q=text_in_r[76]
Xtext_in_r_reg[75] EDFCNQD1BWP7T $PINS D=text_in[75] E=ld CP=clk CDN=rst
+ Q=text_in_r[75]
Xtext_in_r_reg[74] EDFCNQD1BWP7T $PINS D=text_in[74] E=ld CP=clk CDN=rst
+ Q=text_in_r[74]
Xtext_in_r_reg[73] EDFCNQD1BWP7T $PINS D=text_in[73] E=ld CP=clk CDN=rst
+ Q=text_in_r[73]
Xtext_in_r_reg[72] EDFCNQD1BWP7T $PINS D=text_in[72] E=ld CP=clk CDN=rst
+ Q=text_in_r[72]
Xtext_in_r_reg[71] EDFCNQD1BWP7T $PINS D=text_in[71] E=ld CP=clk CDN=rst
+ Q=text_in_r[71]
Xtext_in_r_reg[70] EDFCNQD1BWP7T $PINS D=text_in[70] E=ld CP=clk CDN=rst
+ Q=text_in_r[70]
Xtext_in_r_reg[69] EDFCNQD1BWP7T $PINS D=text_in[69] E=ld CP=clk CDN=rst
+ Q=text_in_r[69]
Xtext_in_r_reg[68] EDFCNQD1BWP7T $PINS D=text_in[68] E=ld CP=clk CDN=rst
+ Q=text_in_r[68]
Xtext_in_r_reg[67] EDFCNQD1BWP7T $PINS D=text_in[67] E=ld CP=clk CDN=rst
+ Q=text_in_r[67]
Xtext_in_r_reg[66] EDFCNQD1BWP7T $PINS D=text_in[66] E=ld CP=clk CDN=rst
+ Q=text_in_r[66]
Xtext_in_r_reg[65] EDFCNQD1BWP7T $PINS D=text_in[65] E=ld CP=clk CDN=rst
+ Q=text_in_r[65]
Xtext_in_r_reg[64] EDFCNQD1BWP7T $PINS D=text_in[64] E=ld CP=clk CDN=rst
+ Q=text_in_r[64]
Xtext_in_r_reg[63] EDFCNQD1BWP7T $PINS D=text_in[63] E=ld CP=clk CDN=rst
+ Q=text_in_r[63]
Xtext_in_r_reg[62] EDFCNQD1BWP7T $PINS D=text_in[62] E=ld CP=clk CDN=rst
+ Q=text_in_r[62]
Xtext_in_r_reg[61] EDFCNQD1BWP7T $PINS D=text_in[61] E=ld CP=clk CDN=rst
+ Q=text_in_r[61]
Xtext_in_r_reg[60] EDFCNQD1BWP7T $PINS D=text_in[60] E=ld CP=clk CDN=rst
+ Q=text_in_r[60]
Xtext_in_r_reg[59] EDFCNQD1BWP7T $PINS D=text_in[59] E=ld CP=clk CDN=rst
+ Q=text_in_r[59]
Xtext_in_r_reg[58] EDFCNQD1BWP7T $PINS D=text_in[58] E=ld CP=clk CDN=rst
+ Q=text_in_r[58]
Xtext_in_r_reg[57] EDFCNQD1BWP7T $PINS D=text_in[57] E=ld CP=clk CDN=rst
+ Q=text_in_r[57]
Xtext_in_r_reg[56] EDFCNQD1BWP7T $PINS D=text_in[56] E=ld CP=clk CDN=rst
+ Q=text_in_r[56]
Xtext_in_r_reg[55] EDFCNQD1BWP7T $PINS D=text_in[55] E=ld CP=clk CDN=rst
+ Q=text_in_r[55]
Xtext_in_r_reg[54] EDFCNQD1BWP7T $PINS D=text_in[54] E=ld CP=clk CDN=rst
+ Q=text_in_r[54]
Xtext_in_r_reg[53] EDFCNQD1BWP7T $PINS D=text_in[53] E=ld CP=clk CDN=rst
+ Q=text_in_r[53]
Xtext_in_r_reg[52] EDFCNQD1BWP7T $PINS D=text_in[52] E=ld CP=clk CDN=rst
+ Q=text_in_r[52]
Xtext_in_r_reg[51] EDFCNQD1BWP7T $PINS D=text_in[51] E=ld CP=clk CDN=rst
+ Q=text_in_r[51]
Xtext_in_r_reg[50] EDFCNQD1BWP7T $PINS D=text_in[50] E=ld CP=clk CDN=rst
+ Q=text_in_r[50]
Xtext_in_r_reg[49] EDFCNQD1BWP7T $PINS D=text_in[49] E=ld CP=clk CDN=rst
+ Q=text_in_r[49]
Xtext_in_r_reg[48] EDFCNQD1BWP7T $PINS D=text_in[48] E=ld CP=clk CDN=rst
+ Q=text_in_r[48]
Xtext_in_r_reg[47] EDFCNQD1BWP7T $PINS D=text_in[47] E=ld CP=clk CDN=rst
+ Q=text_in_r[47]
Xtext_in_r_reg[46] EDFCNQD1BWP7T $PINS D=text_in[46] E=ld CP=clk CDN=rst
+ Q=text_in_r[46]
Xtext_in_r_reg[45] EDFCNQD1BWP7T $PINS D=text_in[45] E=ld CP=clk CDN=rst
+ Q=text_in_r[45]
Xtext_in_r_reg[44] EDFCNQD1BWP7T $PINS D=text_in[44] E=ld CP=clk CDN=rst
+ Q=text_in_r[44]
Xtext_in_r_reg[43] EDFCNQD1BWP7T $PINS D=text_in[43] E=ld CP=clk CDN=rst
+ Q=text_in_r[43]
Xtext_in_r_reg[42] EDFCNQD1BWP7T $PINS D=text_in[42] E=ld CP=clk CDN=rst
+ Q=text_in_r[42]
Xtext_in_r_reg[41] EDFCNQD1BWP7T $PINS D=text_in[41] E=ld CP=clk CDN=rst
+ Q=text_in_r[41]
Xtext_in_r_reg[40] EDFCNQD1BWP7T $PINS D=text_in[40] E=ld CP=clk CDN=rst
+ Q=text_in_r[40]
Xtext_in_r_reg[39] EDFCNQD1BWP7T $PINS D=text_in[39] E=ld CP=clk CDN=rst
+ Q=text_in_r[39]
Xtext_in_r_reg[38] EDFCNQD1BWP7T $PINS D=text_in[38] E=ld CP=clk CDN=rst
+ Q=text_in_r[38]
Xtext_in_r_reg[37] EDFCNQD1BWP7T $PINS D=text_in[37] E=ld CP=clk CDN=rst
+ Q=text_in_r[37]
Xtext_in_r_reg[36] EDFCNQD1BWP7T $PINS D=text_in[36] E=ld CP=clk CDN=rst
+ Q=text_in_r[36]
Xtext_in_r_reg[35] EDFCNQD1BWP7T $PINS D=text_in[35] E=ld CP=clk CDN=rst
+ Q=text_in_r[35]
Xtext_in_r_reg[34] EDFCNQD1BWP7T $PINS D=text_in[34] E=ld CP=clk CDN=rst
+ Q=text_in_r[34]
Xtext_in_r_reg[33] EDFCNQD1BWP7T $PINS D=text_in[33] E=ld CP=clk CDN=rst
+ Q=text_in_r[33]
Xtext_in_r_reg[32] EDFCNQD1BWP7T $PINS D=text_in[32] E=ld CP=clk CDN=rst
+ Q=text_in_r[32]
Xtext_in_r_reg[31] EDFCNQD1BWP7T $PINS D=text_in[31] E=ld CP=clk CDN=rst
+ Q=text_in_r[31]
Xtext_in_r_reg[30] EDFCNQD1BWP7T $PINS D=text_in[30] E=ld CP=clk CDN=rst
+ Q=text_in_r[30]
Xtext_in_r_reg[29] EDFCNQD1BWP7T $PINS D=text_in[29] E=ld CP=clk CDN=rst
+ Q=text_in_r[29]
Xtext_in_r_reg[28] EDFCNQD1BWP7T $PINS D=text_in[28] E=ld CP=clk CDN=rst
+ Q=text_in_r[28]
Xtext_in_r_reg[27] EDFCNQD1BWP7T $PINS D=text_in[27] E=ld CP=clk CDN=rst
+ Q=text_in_r[27]
Xtext_in_r_reg[26] EDFCNQD1BWP7T $PINS D=text_in[26] E=ld CP=clk CDN=rst
+ Q=text_in_r[26]
Xtext_in_r_reg[25] EDFCNQD1BWP7T $PINS D=text_in[25] E=ld CP=clk CDN=rst
+ Q=text_in_r[25]
Xtext_in_r_reg[24] EDFCNQD1BWP7T $PINS D=text_in[24] E=ld CP=clk CDN=rst
+ Q=text_in_r[24]
Xtext_in_r_reg[23] EDFCNQD1BWP7T $PINS D=text_in[23] E=ld CP=clk CDN=rst
+ Q=text_in_r[23]
Xtext_in_r_reg[22] EDFCNQD1BWP7T $PINS D=text_in[22] E=ld CP=clk CDN=rst
+ Q=text_in_r[22]
Xtext_in_r_reg[21] EDFCNQD1BWP7T $PINS D=text_in[21] E=ld CP=clk CDN=rst
+ Q=text_in_r[21]
Xtext_in_r_reg[20] EDFCNQD1BWP7T $PINS D=text_in[20] E=ld CP=clk CDN=rst
+ Q=text_in_r[20]
Xtext_in_r_reg[19] EDFCNQD1BWP7T $PINS D=text_in[19] E=ld CP=clk CDN=rst
+ Q=text_in_r[19]
Xtext_in_r_reg[18] EDFCNQD1BWP7T $PINS D=text_in[18] E=ld CP=clk CDN=rst
+ Q=text_in_r[18]
Xtext_in_r_reg[17] EDFCNQD1BWP7T $PINS D=text_in[17] E=ld CP=clk CDN=rst
+ Q=text_in_r[17]
Xtext_in_r_reg[16] EDFCNQD1BWP7T $PINS D=text_in[16] E=ld CP=clk CDN=rst
+ Q=text_in_r[16]
Xtext_in_r_reg[15] EDFCNQD1BWP7T $PINS D=text_in[15] E=ld CP=clk CDN=rst
+ Q=text_in_r[15]
Xtext_in_r_reg[14] EDFCNQD1BWP7T $PINS D=text_in[14] E=ld CP=clk CDN=rst
+ Q=text_in_r[14]
Xtext_in_r_reg[13] EDFCNQD1BWP7T $PINS D=text_in[13] E=ld CP=clk CDN=rst
+ Q=text_in_r[13]
Xtext_in_r_reg[12] EDFCNQD1BWP7T $PINS D=text_in[12] E=ld CP=clk CDN=rst
+ Q=text_in_r[12]
Xtext_in_r_reg[11] EDFCNQD1BWP7T $PINS D=text_in[11] E=ld CP=clk CDN=rst
+ Q=text_in_r[11]
Xtext_in_r_reg[10] EDFCNQD1BWP7T $PINS D=text_in[10] E=ld CP=clk CDN=rst
+ Q=text_in_r[10]
Xtext_in_r_reg[9] EDFCNQD1BWP7T $PINS D=text_in[9] E=ld CP=clk CDN=rst
+ Q=text_in_r[9]
Xtext_in_r_reg[8] EDFCNQD1BWP7T $PINS D=text_in[8] E=ld CP=clk CDN=rst
+ Q=text_in_r[8]
Xtext_in_r_reg[7] EDFCNQD1BWP7T $PINS D=text_in[7] E=ld CP=clk CDN=rst
+ Q=text_in_r[7]
Xtext_in_r_reg[6] EDFCNQD1BWP7T $PINS D=text_in[6] E=ld CP=clk CDN=rst
+ Q=text_in_r[6]
Xtext_in_r_reg[5] EDFCNQD1BWP7T $PINS D=text_in[5] E=ld CP=clk CDN=rst
+ Q=text_in_r[5]
Xtext_in_r_reg[4] EDFCNQD1BWP7T $PINS D=text_in[4] E=ld CP=clk CDN=rst
+ Q=text_in_r[4]
Xtext_in_r_reg[3] EDFCNQD1BWP7T $PINS D=text_in[3] E=ld CP=clk CDN=rst
+ Q=text_in_r[3]
Xtext_in_r_reg[2] EDFCNQD1BWP7T $PINS D=text_in[2] E=ld CP=clk CDN=rst
+ Q=text_in_r[2]
Xtext_in_r_reg[1] EDFCNQD1BWP7T $PINS D=text_in[1] E=ld CP=clk CDN=rst
+ Q=text_in_r[1]
Xtext_in_r_reg[0] EDFCNQD1BWP7T $PINS D=text_in[0] E=ld CP=clk CDN=rst
+ Q=text_in_r[0]
Xld_r_reg DFQD0BWP7T $PINS D=ld CP=clk Q=ld_r
Xtext_out_reg[127] DFQD0BWP7T $PINS D=N394 CP=clk Q=text_out[127]
Xtext_out_reg[126] DFQD0BWP7T $PINS D=N395 CP=clk Q=text_out[126]
Xtext_out_reg[125] DFQD0BWP7T $PINS D=N396 CP=clk Q=text_out[125]
Xtext_out_reg[124] DFQD0BWP7T $PINS D=N397 CP=clk Q=text_out[124]
Xtext_out_reg[123] DFQD0BWP7T $PINS D=N398 CP=clk Q=text_out[123]
Xtext_out_reg[122] DFQD0BWP7T $PINS D=N399 CP=clk Q=text_out[122]
Xtext_out_reg[121] DFQD0BWP7T $PINS D=N400 CP=clk Q=text_out[121]
Xtext_out_reg[120] DFQD0BWP7T $PINS D=N401 CP=clk Q=text_out[120]
Xtext_out_reg[95] DFQD0BWP7T $PINS D=N402 CP=clk Q=text_out[95]
Xtext_out_reg[94] DFQD0BWP7T $PINS D=N403 CP=clk Q=text_out[94]
Xtext_out_reg[93] DFQD0BWP7T $PINS D=N404 CP=clk Q=text_out[93]
Xtext_out_reg[92] DFQD0BWP7T $PINS D=N405 CP=clk Q=text_out[92]
Xtext_out_reg[91] DFQD0BWP7T $PINS D=N406 CP=clk Q=text_out[91]
Xtext_out_reg[90] DFQD0BWP7T $PINS D=N407 CP=clk Q=text_out[90]
Xtext_out_reg[89] DFQD0BWP7T $PINS D=N408 CP=clk Q=text_out[89]
Xtext_out_reg[88] DFQD0BWP7T $PINS D=N409 CP=clk Q=text_out[88]
Xtext_out_reg[63] DFQD0BWP7T $PINS D=N410 CP=clk Q=text_out[63]
Xtext_out_reg[62] DFQD0BWP7T $PINS D=N411 CP=clk Q=text_out[62]
Xtext_out_reg[61] DFQD0BWP7T $PINS D=N412 CP=clk Q=text_out[61]
Xtext_out_reg[60] DFQD0BWP7T $PINS D=N413 CP=clk Q=text_out[60]
Xtext_out_reg[59] DFQD0BWP7T $PINS D=N414 CP=clk Q=text_out[59]
Xtext_out_reg[58] DFQD0BWP7T $PINS D=N415 CP=clk Q=text_out[58]
Xtext_out_reg[57] DFQD0BWP7T $PINS D=N416 CP=clk Q=text_out[57]
Xtext_out_reg[56] DFQD0BWP7T $PINS D=N417 CP=clk Q=text_out[56]
Xtext_out_reg[31] DFQD0BWP7T $PINS D=N418 CP=clk Q=text_out[31]
Xtext_out_reg[30] DFQD0BWP7T $PINS D=N419 CP=clk Q=text_out[30]
Xtext_out_reg[29] DFQD0BWP7T $PINS D=N420 CP=clk Q=text_out[29]
Xtext_out_reg[28] DFQD0BWP7T $PINS D=N421 CP=clk Q=text_out[28]
Xtext_out_reg[27] DFQD0BWP7T $PINS D=N422 CP=clk Q=text_out[27]
Xtext_out_reg[26] DFQD0BWP7T $PINS D=N423 CP=clk Q=text_out[26]
Xtext_out_reg[25] DFQD0BWP7T $PINS D=N424 CP=clk Q=text_out[25]
Xtext_out_reg[24] DFQD0BWP7T $PINS D=N425 CP=clk Q=text_out[24]
Xtext_out_reg[119] DFQD0BWP7T $PINS D=N426 CP=clk Q=text_out[119]
Xtext_out_reg[118] DFQD0BWP7T $PINS D=N427 CP=clk Q=text_out[118]
Xtext_out_reg[117] DFQD0BWP7T $PINS D=N428 CP=clk Q=text_out[117]
Xtext_out_reg[116] DFQD0BWP7T $PINS D=N429 CP=clk Q=text_out[116]
Xtext_out_reg[115] DFQD0BWP7T $PINS D=N430 CP=clk Q=text_out[115]
Xtext_out_reg[114] DFQD0BWP7T $PINS D=N431 CP=clk Q=text_out[114]
Xtext_out_reg[113] DFQD0BWP7T $PINS D=N432 CP=clk Q=text_out[113]
Xtext_out_reg[112] DFQD0BWP7T $PINS D=N433 CP=clk Q=text_out[112]
Xtext_out_reg[87] DFQD0BWP7T $PINS D=N434 CP=clk Q=text_out[87]
Xtext_out_reg[86] DFQD0BWP7T $PINS D=N435 CP=clk Q=text_out[86]
Xtext_out_reg[85] DFQD0BWP7T $PINS D=N436 CP=clk Q=text_out[85]
Xtext_out_reg[84] DFQD0BWP7T $PINS D=N437 CP=clk Q=text_out[84]
Xtext_out_reg[83] DFQD0BWP7T $PINS D=N438 CP=clk Q=text_out[83]
Xtext_out_reg[82] DFQD0BWP7T $PINS D=N439 CP=clk Q=text_out[82]
Xtext_out_reg[81] DFQD0BWP7T $PINS D=N440 CP=clk Q=text_out[81]
Xtext_out_reg[80] DFQD0BWP7T $PINS D=N441 CP=clk Q=text_out[80]
Xtext_out_reg[55] DFQD0BWP7T $PINS D=N442 CP=clk Q=text_out[55]
Xtext_out_reg[54] DFQD0BWP7T $PINS D=N443 CP=clk Q=text_out[54]
Xtext_out_reg[53] DFQD0BWP7T $PINS D=N444 CP=clk Q=text_out[53]
Xtext_out_reg[52] DFQD0BWP7T $PINS D=N445 CP=clk Q=text_out[52]
Xtext_out_reg[51] DFQD0BWP7T $PINS D=N446 CP=clk Q=text_out[51]
Xtext_out_reg[50] DFQD0BWP7T $PINS D=N447 CP=clk Q=text_out[50]
Xtext_out_reg[49] DFQD0BWP7T $PINS D=N448 CP=clk Q=text_out[49]
Xtext_out_reg[48] DFQD0BWP7T $PINS D=N449 CP=clk Q=text_out[48]
Xtext_out_reg[23] DFQD0BWP7T $PINS D=N450 CP=clk Q=text_out[23]
Xtext_out_reg[22] DFQD0BWP7T $PINS D=N451 CP=clk Q=text_out[22]
Xtext_out_reg[21] DFQD0BWP7T $PINS D=N452 CP=clk Q=text_out[21]
Xtext_out_reg[20] DFQD0BWP7T $PINS D=N453 CP=clk Q=text_out[20]
Xtext_out_reg[19] DFQD0BWP7T $PINS D=N454 CP=clk Q=text_out[19]
Xtext_out_reg[18] DFQD0BWP7T $PINS D=N455 CP=clk Q=text_out[18]
Xtext_out_reg[17] DFQD0BWP7T $PINS D=N456 CP=clk Q=text_out[17]
Xtext_out_reg[16] DFQD0BWP7T $PINS D=N457 CP=clk Q=text_out[16]
Xtext_out_reg[111] DFQD0BWP7T $PINS D=N458 CP=clk Q=text_out[111]
Xtext_out_reg[110] DFQD0BWP7T $PINS D=N459 CP=clk Q=text_out[110]
Xtext_out_reg[109] DFQD0BWP7T $PINS D=N460 CP=clk Q=text_out[109]
Xtext_out_reg[108] DFQD0BWP7T $PINS D=N461 CP=clk Q=text_out[108]
Xtext_out_reg[107] DFQD0BWP7T $PINS D=N462 CP=clk Q=text_out[107]
Xtext_out_reg[106] DFQD0BWP7T $PINS D=N463 CP=clk Q=text_out[106]
Xtext_out_reg[105] DFQD0BWP7T $PINS D=N464 CP=clk Q=text_out[105]
Xtext_out_reg[104] DFQD0BWP7T $PINS D=N465 CP=clk Q=text_out[104]
Xtext_out_reg[79] DFQD0BWP7T $PINS D=N466 CP=clk Q=text_out[79]
Xtext_out_reg[78] DFQD0BWP7T $PINS D=N467 CP=clk Q=text_out[78]
Xtext_out_reg[77] DFQD0BWP7T $PINS D=N468 CP=clk Q=text_out[77]
Xtext_out_reg[76] DFQD0BWP7T $PINS D=N469 CP=clk Q=text_out[76]
Xtext_out_reg[75] DFQD0BWP7T $PINS D=N470 CP=clk Q=text_out[75]
Xtext_out_reg[74] DFQD0BWP7T $PINS D=N471 CP=clk Q=text_out[74]
Xtext_out_reg[73] DFQD0BWP7T $PINS D=N472 CP=clk Q=text_out[73]
Xtext_out_reg[72] DFQD0BWP7T $PINS D=N473 CP=clk Q=text_out[72]
Xtext_out_reg[47] DFQD0BWP7T $PINS D=N474 CP=clk Q=text_out[47]
Xtext_out_reg[46] DFQD0BWP7T $PINS D=N475 CP=clk Q=text_out[46]
Xtext_out_reg[45] DFQD0BWP7T $PINS D=N476 CP=clk Q=text_out[45]
Xtext_out_reg[44] DFQD0BWP7T $PINS D=N477 CP=clk Q=text_out[44]
Xtext_out_reg[43] DFQD0BWP7T $PINS D=N478 CP=clk Q=text_out[43]
Xtext_out_reg[42] DFQD0BWP7T $PINS D=N479 CP=clk Q=text_out[42]
Xtext_out_reg[41] DFQD0BWP7T $PINS D=N480 CP=clk Q=text_out[41]
Xtext_out_reg[40] DFQD0BWP7T $PINS D=N481 CP=clk Q=text_out[40]
Xtext_out_reg[15] DFQD0BWP7T $PINS D=N482 CP=clk Q=text_out[15]
Xtext_out_reg[14] DFQD0BWP7T $PINS D=N483 CP=clk Q=text_out[14]
Xtext_out_reg[13] DFQD0BWP7T $PINS D=N484 CP=clk Q=text_out[13]
Xtext_out_reg[12] DFQD0BWP7T $PINS D=N485 CP=clk Q=text_out[12]
Xtext_out_reg[11] DFQD0BWP7T $PINS D=N486 CP=clk Q=text_out[11]
Xtext_out_reg[10] DFQD0BWP7T $PINS D=N487 CP=clk Q=text_out[10]
Xtext_out_reg[9] DFQD0BWP7T $PINS D=N488 CP=clk Q=text_out[9]
Xtext_out_reg[8] DFQD0BWP7T $PINS D=N489 CP=clk Q=text_out[8]
Xtext_out_reg[103] DFQD0BWP7T $PINS D=N490 CP=clk Q=text_out[103]
Xtext_out_reg[102] DFQD0BWP7T $PINS D=N491 CP=clk Q=text_out[102]
Xtext_out_reg[101] DFQD0BWP7T $PINS D=N492 CP=clk Q=text_out[101]
Xtext_out_reg[100] DFQD0BWP7T $PINS D=N493 CP=clk Q=text_out[100]
Xtext_out_reg[99] DFQD0BWP7T $PINS D=N494 CP=clk Q=text_out[99]
Xtext_out_reg[98] DFQD0BWP7T $PINS D=N495 CP=clk Q=text_out[98]
Xtext_out_reg[97] DFQD0BWP7T $PINS D=N496 CP=clk Q=text_out[97]
Xtext_out_reg[96] DFQD0BWP7T $PINS D=N497 CP=clk Q=text_out[96]
Xtext_out_reg[71] DFQD0BWP7T $PINS D=N498 CP=clk Q=text_out[71]
Xtext_out_reg[70] DFQD0BWP7T $PINS D=N499 CP=clk Q=text_out[70]
Xtext_out_reg[69] DFQD0BWP7T $PINS D=N500 CP=clk Q=text_out[69]
Xtext_out_reg[68] DFQD0BWP7T $PINS D=N501 CP=clk Q=text_out[68]
Xtext_out_reg[67] DFQD0BWP7T $PINS D=N502 CP=clk Q=text_out[67]
Xtext_out_reg[66] DFQD0BWP7T $PINS D=N503 CP=clk Q=text_out[66]
Xtext_out_reg[65] DFQD0BWP7T $PINS D=N504 CP=clk Q=text_out[65]
Xtext_out_reg[64] DFQD0BWP7T $PINS D=N505 CP=clk Q=text_out[64]
Xtext_out_reg[39] DFQD0BWP7T $PINS D=N506 CP=clk Q=text_out[39]
Xtext_out_reg[38] DFQD0BWP7T $PINS D=N507 CP=clk Q=text_out[38]
Xtext_out_reg[37] DFQD0BWP7T $PINS D=N508 CP=clk Q=text_out[37]
Xtext_out_reg[36] DFQD0BWP7T $PINS D=N509 CP=clk Q=text_out[36]
Xtext_out_reg[35] DFQD0BWP7T $PINS D=N510 CP=clk Q=text_out[35]
Xtext_out_reg[34] DFQD0BWP7T $PINS D=N511 CP=clk Q=text_out[34]
Xtext_out_reg[33] DFQD0BWP7T $PINS D=N512 CP=clk Q=text_out[33]
Xtext_out_reg[32] DFQD0BWP7T $PINS D=N513 CP=clk Q=text_out[32]
Xtext_out_reg[7] DFQD0BWP7T $PINS D=N514 CP=clk Q=text_out[7]
Xtext_out_reg[6] DFQD0BWP7T $PINS D=N515 CP=clk Q=text_out[6]
Xtext_out_reg[5] DFQD0BWP7T $PINS D=N516 CP=clk Q=text_out[5]
Xtext_out_reg[4] DFQD0BWP7T $PINS D=N517 CP=clk Q=text_out[4]
Xtext_out_reg[3] DFQD0BWP7T $PINS D=N518 CP=clk Q=text_out[3]
Xtext_out_reg[2] DFQD0BWP7T $PINS D=N519 CP=clk Q=text_out[2]
Xtext_out_reg[1] DFQD0BWP7T $PINS D=N520 CP=clk Q=text_out[1]
Xtext_out_reg[0] DFQD0BWP7T $PINS D=N521 CP=clk Q=text_out[0]
Xdcnt_reg[3] DFCNQD1BWP7T $PINS D=n512 CP=clk CDN=rst Q=dcnt[3]
Xsa23_reg[7] DFCNQD1BWP7T $PINS D=N59 CP=clk CDN=rst Q=sa23[7]
Xsa03_reg[7] DFCNQD1BWP7T $PINS D=N93 CP=clk CDN=rst Q=sa03[7]
Xsa03_reg[1] DFCNQD1BWP7T $PINS D=N87 CP=clk CDN=rst Q=sa03[1]
Xsa13_reg[1] DFCNQD1BWP7T $PINS D=N70 CP=clk CDN=rst Q=sa13[1]
Xsa33_reg[1] DFCNQD1BWP7T $PINS D=N36 CP=clk CDN=rst Q=sa33[1]
Xsa03_reg[3] DFCNQD1BWP7T $PINS D=N89 CP=clk CDN=rst Q=sa03[3]
Xsa13_reg[3] DFCNQD1BWP7T $PINS D=N72 CP=clk CDN=rst Q=sa13[3]
Xsa33_reg[3] DFCNQD1BWP7T $PINS D=N38 CP=clk CDN=rst Q=sa33[3]
Xsa03_reg[5] DFCNQD1BWP7T $PINS D=N91 CP=clk CDN=rst Q=sa03[5]
Xsa13_reg[5] DFCNQD1BWP7T $PINS D=N74 CP=clk CDN=rst Q=sa13[5]
Xsa23_reg[5] DFCNQD1BWP7T $PINS D=N57 CP=clk CDN=rst Q=sa23[5]
Xsa33_reg[5] DFCNQD1BWP7T $PINS D=N40 CP=clk CDN=rst Q=sa33[5]
Xsa13_reg[7] DFCNQD1BWP7T $PINS D=N76 CP=clk CDN=rst Q=sa13[7]
Xsa02_reg[1] DFCNQD1BWP7T $PINS D=N155 CP=clk CDN=rst Q=sa02[1]
Xsa12_reg[1] DFCNQD1BWP7T $PINS D=N138 CP=clk CDN=rst Q=sa12[1]
Xsa22_reg[1] DFCNQD1BWP7T $PINS D=N121 CP=clk CDN=rst Q=sa22[1]
Xsa32_reg[1] DFCNQD1BWP7T $PINS D=N104 CP=clk CDN=rst Q=sa32[1]
Xsa02_reg[3] DFCNQD1BWP7T $PINS D=N157 CP=clk CDN=rst Q=sa02[3]
Xsa12_reg[3] DFCNQD1BWP7T $PINS D=N140 CP=clk CDN=rst Q=sa12[3]
Xsa22_reg[3] DFCNQD1BWP7T $PINS D=N123 CP=clk CDN=rst Q=sa22[3]
Xsa32_reg[3] DFCNQD1BWP7T $PINS D=N106 CP=clk CDN=rst Q=sa32[3]
Xsa02_reg[5] DFCNQD1BWP7T $PINS D=N159 CP=clk CDN=rst Q=sa02[5]
Xsa12_reg[5] DFCNQD1BWP7T $PINS D=N142 CP=clk CDN=rst Q=sa12[5]
Xsa22_reg[5] DFCNQD1BWP7T $PINS D=N125 CP=clk CDN=rst Q=sa22[5]
Xsa32_reg[5] DFCNQD1BWP7T $PINS D=N108 CP=clk CDN=rst Q=sa32[5]
Xsa02_reg[7] DFCNQD1BWP7T $PINS D=N161 CP=clk CDN=rst Q=sa02[7]
Xsa12_reg[7] DFCNQD1BWP7T $PINS D=N144 CP=clk CDN=rst Q=sa12[7]
Xsa01_reg[1] DFCNQD1BWP7T $PINS D=N223 CP=clk CDN=rst Q=sa01[1]
Xsa11_reg[1] DFCNQD1BWP7T $PINS D=N206 CP=clk CDN=rst Q=sa11[1]
Xsa21_reg[1] DFCNQD1BWP7T $PINS D=N189 CP=clk CDN=rst Q=sa21[1]
Xsa31_reg[1] DFCNQD1BWP7T $PINS D=N172 CP=clk CDN=rst Q=sa31[1]
Xsa01_reg[3] DFCNQD1BWP7T $PINS D=N225 CP=clk CDN=rst Q=sa01[3]
Xsa11_reg[3] DFCNQD1BWP7T $PINS D=N208 CP=clk CDN=rst Q=sa11[3]
Xsa21_reg[3] DFCNQD1BWP7T $PINS D=N191 CP=clk CDN=rst Q=sa21[3]
Xsa31_reg[3] DFCNQD1BWP7T $PINS D=N174 CP=clk CDN=rst Q=sa31[3]
Xsa01_reg[5] DFCNQD1BWP7T $PINS D=N227 CP=clk CDN=rst Q=sa01[5]
Xsa11_reg[5] DFCNQD1BWP7T $PINS D=N210 CP=clk CDN=rst Q=sa11[5]
Xsa21_reg[5] DFCNQD1BWP7T $PINS D=N193 CP=clk CDN=rst Q=sa21[5]
Xsa31_reg[5] DFCNQD1BWP7T $PINS D=N176 CP=clk CDN=rst Q=sa31[5]
Xsa01_reg[7] DFCNQD1BWP7T $PINS D=N229 CP=clk CDN=rst Q=sa01[7]
Xsa11_reg[7] DFCNQD1BWP7T $PINS D=N212 CP=clk CDN=rst Q=sa11[7]
Xsa10_reg[1] DFCNQD1BWP7T $PINS D=N274 CP=clk CDN=rst Q=sa10[1]
Xsa20_reg[1] DFCNQD1BWP7T $PINS D=N257 CP=clk CDN=rst Q=sa20[1]
Xsa30_reg[1] DFCNQD1BWP7T $PINS D=N240 CP=clk CDN=rst Q=sa30[1]
Xsa10_reg[3] DFCNQD1BWP7T $PINS D=N276 CP=clk CDN=rst Q=sa10[3]
Xsa20_reg[3] DFCNQD1BWP7T $PINS D=N259 CP=clk CDN=rst Q=sa20[3]
Xsa30_reg[3] DFCNQD1BWP7T $PINS D=N242 CP=clk CDN=rst Q=sa30[3]
Xsa10_reg[5] DFCNQD1BWP7T $PINS D=N278 CP=clk CDN=rst Q=sa10[5]
Xsa00_reg[5] DFCNQD1BWP7T $PINS D=N295 CP=clk CDN=rst Q=sa00[5]
Xsa20_reg[5] DFCNQD1BWP7T $PINS D=N261 CP=clk CDN=rst Q=sa20[5]
Xsa30_reg[5] DFCNQD1BWP7T $PINS D=N244 CP=clk CDN=rst Q=sa30[5]
Xsa10_reg[7] DFCNQD1BWP7T $PINS D=N280 CP=clk CDN=rst Q=sa10[7]
Xsa00_reg[7] DFCNQD1BWP7T $PINS D=N297 CP=clk CDN=rst Q=sa00[7]
Xsa00_reg[3] DFCNQD1BWP7T $PINS D=N293 CP=clk CDN=rst Q=sa00[3]
Xsa00_reg[1] DFCNQD1BWP7T $PINS D=N291 CP=clk CDN=rst Q=sa00[1]
Xsa20_reg[7] DFCNQD1BWP7T $PINS D=N263 CP=clk CDN=rst Q=sa20[7]
Xsa30_reg[7] DFCNQD1BWP7T $PINS D=N246 CP=clk CDN=rst Q=sa30[7]
Xsa21_reg[7] DFCNQD1BWP7T $PINS D=N195 CP=clk CDN=rst Q=sa21[7]
Xsa31_reg[7] DFCNQD1BWP7T $PINS D=N178 CP=clk CDN=rst Q=sa31[7]
Xsa22_reg[7] DFCNQD1BWP7T $PINS D=N127 CP=clk CDN=rst Q=sa22[7]
Xsa32_reg[7] DFCNQD1BWP7T $PINS D=N110 CP=clk CDN=rst Q=sa32[7]
Xsa23_reg[3] DFCNQD1BWP7T $PINS D=N55 CP=clk CDN=rst Q=sa23[3]
Xsa23_reg[1] DFCNQD1BWP7T $PINS D=N53 CP=clk CDN=rst Q=sa23[1]
Xsa33_reg[7] DFCNQD1BWP7T $PINS D=N42 CP=clk CDN=rst Q=sa33[7]
Xsa00_reg[0] DFCNQD1BWP7T $PINS D=N290 CP=clk CDN=rst Q=sa00[0]
Xsa30_reg[0] DFCNQD1BWP7T $PINS D=N239 CP=clk CDN=rst Q=sa30[0]
Xsa31_reg[0] DFCNQD1BWP7T $PINS D=N171 CP=clk CDN=rst Q=sa31[0]
Xsa32_reg[0] DFCNQD1BWP7T $PINS D=N103 CP=clk CDN=rst Q=sa32[0]
Xsa33_reg[0] DFCNQD1BWP7T $PINS D=N35 CP=clk CDN=rst Q=sa33[0]
Xsa20_reg[0] DFCNQD1BWP7T $PINS D=N256 CP=clk CDN=rst Q=sa20[0]
Xsa22_reg[0] DFCNQD1BWP7T $PINS D=N120 CP=clk CDN=rst Q=sa22[0]
Xsa10_reg[0] DFCNQD1BWP7T $PINS D=N273 CP=clk CDN=rst Q=sa10[0]
Xsa21_reg[0] DFCNQD1BWP7T $PINS D=N188 CP=clk CDN=rst Q=sa21[0]
Xsa03_reg[0] DFCNQD1BWP7T $PINS D=N86 CP=clk CDN=rst Q=sa03[0]
Xsa13_reg[0] DFCNQD1BWP7T $PINS D=N69 CP=clk CDN=rst Q=sa13[0]
Xsa03_reg[2] DFCNQD1BWP7T $PINS D=N88 CP=clk CDN=rst Q=sa03[2]
Xsa13_reg[2] DFCNQD1BWP7T $PINS D=N71 CP=clk CDN=rst Q=sa13[2]
Xsa23_reg[2] DFCNQD1BWP7T $PINS D=N54 CP=clk CDN=rst Q=sa23[2]
Xsa33_reg[2] DFCNQD1BWP7T $PINS D=N37 CP=clk CDN=rst Q=sa33[2]
Xsa03_reg[4] DFCNQD1BWP7T $PINS D=N90 CP=clk CDN=rst Q=sa03[4]
Xsa13_reg[4] DFCNQD1BWP7T $PINS D=N73 CP=clk CDN=rst Q=sa13[4]
Xsa33_reg[4] DFCNQD1BWP7T $PINS D=N39 CP=clk CDN=rst Q=sa33[4]
Xsa03_reg[6] DFCNQD1BWP7T $PINS D=N92 CP=clk CDN=rst Q=sa03[6]
Xsa13_reg[6] DFCNQD1BWP7T $PINS D=N75 CP=clk CDN=rst Q=sa13[6]
Xsa23_reg[6] DFCNQD1BWP7T $PINS D=N58 CP=clk CDN=rst Q=sa23[6]
Xsa33_reg[6] DFCNQD1BWP7T $PINS D=N41 CP=clk CDN=rst Q=sa33[6]
Xsa02_reg[0] DFCNQD1BWP7T $PINS D=N154 CP=clk CDN=rst Q=sa02[0]
Xsa12_reg[0] DFCNQD1BWP7T $PINS D=N137 CP=clk CDN=rst Q=sa12[0]
Xsa02_reg[2] DFCNQD1BWP7T $PINS D=N156 CP=clk CDN=rst Q=sa02[2]
Xsa12_reg[2] DFCNQD1BWP7T $PINS D=N139 CP=clk CDN=rst Q=sa12[2]
Xsa22_reg[2] DFCNQD1BWP7T $PINS D=N122 CP=clk CDN=rst Q=sa22[2]
Xsa32_reg[2] DFCNQD1BWP7T $PINS D=N105 CP=clk CDN=rst Q=sa32[2]
Xsa02_reg[4] DFCNQD1BWP7T $PINS D=N158 CP=clk CDN=rst Q=sa02[4]
Xsa12_reg[4] DFCNQD1BWP7T $PINS D=N141 CP=clk CDN=rst Q=sa12[4]
Xsa22_reg[4] DFCNQD1BWP7T $PINS D=N124 CP=clk CDN=rst Q=sa22[4]
Xsa32_reg[4] DFCNQD1BWP7T $PINS D=N107 CP=clk CDN=rst Q=sa32[4]
Xsa02_reg[6] DFCNQD1BWP7T $PINS D=N160 CP=clk CDN=rst Q=sa02[6]
Xsa12_reg[6] DFCNQD1BWP7T $PINS D=N143 CP=clk CDN=rst Q=sa12[6]
Xsa22_reg[6] DFCNQD1BWP7T $PINS D=N126 CP=clk CDN=rst Q=sa22[6]
Xsa32_reg[6] DFCNQD1BWP7T $PINS D=N109 CP=clk CDN=rst Q=sa32[6]
Xsa01_reg[0] DFCNQD1BWP7T $PINS D=N222 CP=clk CDN=rst Q=sa01[0]
Xsa11_reg[0] DFCNQD1BWP7T $PINS D=N205 CP=clk CDN=rst Q=sa11[0]
Xsa01_reg[2] DFCNQD1BWP7T $PINS D=N224 CP=clk CDN=rst Q=sa01[2]
Xsa11_reg[2] DFCNQD1BWP7T $PINS D=N207 CP=clk CDN=rst Q=sa11[2]
Xsa21_reg[2] DFCNQD1BWP7T $PINS D=N190 CP=clk CDN=rst Q=sa21[2]
Xsa31_reg[2] DFCNQD1BWP7T $PINS D=N173 CP=clk CDN=rst Q=sa31[2]
Xsa01_reg[4] DFCNQD1BWP7T $PINS D=N226 CP=clk CDN=rst Q=sa01[4]
Xsa11_reg[4] DFCNQD1BWP7T $PINS D=N209 CP=clk CDN=rst Q=sa11[4]
Xsa21_reg[4] DFCNQD1BWP7T $PINS D=N192 CP=clk CDN=rst Q=sa21[4]
Xsa31_reg[4] DFCNQD1BWP7T $PINS D=N175 CP=clk CDN=rst Q=sa31[4]
Xsa01_reg[6] DFCNQD1BWP7T $PINS D=N228 CP=clk CDN=rst Q=sa01[6]
Xsa11_reg[6] DFCNQD1BWP7T $PINS D=N211 CP=clk CDN=rst Q=sa11[6]
Xsa21_reg[6] DFCNQD1BWP7T $PINS D=N194 CP=clk CDN=rst Q=sa21[6]
Xsa31_reg[6] DFCNQD1BWP7T $PINS D=N177 CP=clk CDN=rst Q=sa31[6]
Xsa10_reg[2] DFCNQD1BWP7T $PINS D=N275 CP=clk CDN=rst Q=sa10[2]
Xsa00_reg[2] DFCNQD1BWP7T $PINS D=N292 CP=clk CDN=rst Q=sa00[2]
Xsa20_reg[2] DFCNQD1BWP7T $PINS D=N258 CP=clk CDN=rst Q=sa20[2]
Xsa30_reg[2] DFCNQD1BWP7T $PINS D=N241 CP=clk CDN=rst Q=sa30[2]
Xsa10_reg[4] DFCNQD1BWP7T $PINS D=N277 CP=clk CDN=rst Q=sa10[4]
Xsa20_reg[4] DFCNQD1BWP7T $PINS D=N260 CP=clk CDN=rst Q=sa20[4]
Xsa30_reg[4] DFCNQD1BWP7T $PINS D=N243 CP=clk CDN=rst Q=sa30[4]
Xsa10_reg[6] DFCNQD1BWP7T $PINS D=N279 CP=clk CDN=rst Q=sa10[6]
Xsa00_reg[6] DFCNQD1BWP7T $PINS D=N296 CP=clk CDN=rst Q=sa00[6]
Xsa20_reg[6] DFCNQD1BWP7T $PINS D=N262 CP=clk CDN=rst Q=sa20[6]
Xsa30_reg[6] DFCNQD1BWP7T $PINS D=N245 CP=clk CDN=rst Q=sa30[6]
Xsa00_reg[4] DFCNQD1BWP7T $PINS D=N294 CP=clk CDN=rst Q=sa00[4]
Xsa23_reg[4] DFCNQD1BWP7T $PINS D=N56 CP=clk CDN=rst Q=sa23[4]
Xsa23_reg[0] DFCNQD1BWP7T $PINS D=N52 CP=clk CDN=rst Q=sa23[0]
Xdcnt_reg[1] DFCNQD1BWP7T $PINS D=n510 CP=clk CDN=rst Q=dcnt[1]
Xdcnt_reg[2] DFCNQD1BWP7T $PINS D=n511 CP=clk CDN=rst Q=dcnt[2]
Xdcnt_reg[0] DFCNQD1BWP7T $PINS D=n513 CP=clk CDN=rst Q=dcnt[0]
XU773 CKBD1BWP7T $PINS I=n528 Z=n522
XU774 CKBD1BWP7T $PINS I=n527 Z=n524
XU775 CKBD1BWP7T $PINS I=n527 Z=n525
XU776 CKBD1BWP7T $PINS I=n529 Z=n520
XU777 CKBD1BWP7T $PINS I=n529 Z=n518
XU778 CKBD1BWP7T $PINS I=n528 Z=n523
XU779 CKBD1BWP7T $PINS I=n528 Z=n521
XU780 CKBD1BWP7T $PINS I=n529 Z=n519
XU781 CKBD1BWP7T $PINS I=n530 Z=n516
XU782 CKBD1BWP7T $PINS I=n530 Z=n517
XU783 CKBD1BWP7T $PINS I=n527 Z=n526
XU784 CKBD1BWP7T $PINS I=n514 Z=n527
XU785 CKBD1BWP7T $PINS I=n514 Z=n528
XU786 CKBD1BWP7T $PINS I=n515 Z=n529
XU787 CKBD1BWP7T $PINS I=n515 Z=n530
XU788 INVD1BWP7T $PINS I=ld ZN=n531
XU789 CKBD1BWP7T $PINS I=ld_r Z=n514
XU790 CKBD1BWP7T $PINS I=ld_r Z=n515
XU791 OAI21D0BWP7T $PINS A1=dcnt[0] A2=n532 B=n531 ZN=n513
XU792 NR2D0BWP7T $PINS A1=dcnt[1] A2=n533 ZN=n532
XU793 OAI21D0BWP7T $PINS A1=n534 A2=n535 B=n531 ZN=n512
XU794 NR2D0BWP7T $PINS A1=dcnt[2] A2=n536 ZN=n534
XU795 NR2D0BWP7T $PINS A1=ld A2=n537 ZN=n511
XU796 MUX2ND0BWP7T $PINS I0=n538 I1=n536 S=dcnt[2] ZN=n537
XU797 NR2D0BWP7T $PINS A1=n536 A2=n535 ZN=n538
XU798 OR2D0BWP7T $PINS A1=n539 A2=dcnt[0] Z=n536
XU799 OAI21D0BWP7T $PINS A1=n540 A2=n539 B=n531 ZN=n510
XU800 CKXOR2D0BWP7T $PINS A1=dcnt[0] A2=dcnt[1] Z=n539
XU801 NR2D0BWP7T $PINS A1=dcnt[0] A2=n533 ZN=n540
XU802 MUX2ND0BWP7T $PINS I0=n541 I1=n542 S=n516 ZN=N93
XU803 XNR2D1BWP7T $PINS A1=text_in_r[31] A2=w3[31] ZN=n542
XU804 XOR4D0BWP7T $PINS A1=n543 A2=n544 A3=sa13_sr[7] A4=n545 Z=n541
XU805 MUX2ND0BWP7T $PINS I0=n546 I1=n547 S=n516 ZN=N92
XU806 XNR2D1BWP7T $PINS A1=text_in_r[30] A2=w3[30] ZN=n547
XU807 XOR4D0BWP7T $PINS A1=n548 A2=n549 A3=n550 A4=w3[30] Z=n546
XU808 MUX2ND0BWP7T $PINS I0=n551 I1=n552 S=n516 ZN=N91
XU809 XNR2D1BWP7T $PINS A1=text_in_r[29] A2=w3[29] ZN=n552
XU810 XOR4D0BWP7T $PINS A1=n553 A2=n554 A3=sa13_sr[5] A4=w3[29] Z=n551
XU811 CKND0BWP7T $PINS I=n555 ZN=n553
XU812 MUX2ND0BWP7T $PINS I0=n556 I1=n557 S=n516 ZN=N90
XU813 XNR2D1BWP7T $PINS A1=text_in_r[28] A2=w3[28] ZN=n557
XU814 XOR4D0BWP7T $PINS A1=n558 A2=n559 A3=n560 A4=n561 Z=n556
XU815 XNR2D1BWP7T $PINS A1=sa13_sr[4] A2=w3[28] ZN=n560
XU816 MUX2ND0BWP7T $PINS I0=n562 I1=n563 S=n516 ZN=N89
XU817 XNR2D1BWP7T $PINS A1=text_in_r[27] A2=w3[27] ZN=n563
XU818 XOR4D0BWP7T $PINS A1=n564 A2=n565 A3=n566 A4=n558 Z=n562
XU819 XNR2D1BWP7T $PINS A1=sa13_sr[3] A2=w3[27] ZN=n566
XU820 MUX2ND0BWP7T $PINS I0=n567 I1=n568 S=n516 ZN=N88
XU821 XNR2D1BWP7T $PINS A1=text_in_r[26] A2=w3[26] ZN=n568
XU822 XOR4D0BWP7T $PINS A1=n569 A2=n570 A3=sa13_sr[2] A4=w3[26] Z=n567
XU823 MUX2ND0BWP7T $PINS I0=n571 I1=n572 S=n516 ZN=N87
XU824 XNR2D1BWP7T $PINS A1=text_in_r[25] A2=w3[25] ZN=n572
XU825 XOR4D0BWP7T $PINS A1=n573 A2=n574 A3=n575 A4=n558 Z=n571
XU826 XNR2D1BWP7T $PINS A1=sa13_sr[1] A2=w3[25] ZN=n575
XU827 MUX2ND0BWP7T $PINS I0=n576 I1=n577 S=n516 ZN=N86
XU828 XNR2D1BWP7T $PINS A1=text_in_r[24] A2=w3[24] ZN=n577
XU829 XOR4D0BWP7T $PINS A1=n558 A2=n578 A3=sa13_sr[0] A4=n579 Z=n576
XU830 MUX2ND0BWP7T $PINS I0=n580 I1=n581 S=n516 ZN=N76
XU831 XNR2D1BWP7T $PINS A1=text_in_r[23] A2=w3[23] ZN=n581
XU832 XOR4D0BWP7T $PINS A1=n550 A2=n582 A3=sa03_sr[7] A4=n544 Z=n580
XU833 XNR2D1BWP7T $PINS A1=n583 A2=sa23_sr[6] ZN=n582
XU834 MUX2ND0BWP7T $PINS I0=n584 I1=n585 S=n516 ZN=N75
XU835 XNR2D1BWP7T $PINS A1=text_in_r[22] A2=w3[22] ZN=n585
XU836 XOR4D0BWP7T $PINS A1=sa13_sr[5] A2=n586 A3=n587 A4=n548 Z=n584
XU837 XNR2D1BWP7T $PINS A1=n588 A2=sa23_sr[5] ZN=n586
XU838 MUX2ND0BWP7T $PINS I0=n589 I1=n590 S=n516 ZN=N74
XU839 XNR2D1BWP7T $PINS A1=text_in_r[21] A2=w3[21] ZN=n590
XU840 XOR4D0BWP7T $PINS A1=sa13_sr[4] A2=n591 A3=n592 A4=n554 Z=n589
XU841 XNR2D1BWP7T $PINS A1=n593 A2=sa23_sr[4] ZN=n591
XU842 MUX2ND0BWP7T $PINS I0=n594 I1=n595 S=n516 ZN=N73
XU843 XNR2D1BWP7T $PINS A1=text_in_r[20] A2=w3[20] ZN=n595
XU844 XOR4D0BWP7T $PINS A1=n596 A2=sa03_sr[4] A3=n597 A4=n598 Z=n594
XU845 XNR3D0BWP7T $PINS A1=n599 A2=sa23_sr[3] A3=sa13_sr[3] ZN=n596
XU846 MUX2ND0BWP7T $PINS I0=n600 I1=n601 S=n517 ZN=N72
XU847 XNR2D1BWP7T $PINS A1=text_in_r[19] A2=w3[19] ZN=n601
XU848 XOR4D0BWP7T $PINS A1=n602 A2=sa03_sr[3] A3=n565 A4=n598 Z=n600
XU849 XNR3D0BWP7T $PINS A1=n603 A2=sa23_sr[2] A3=sa13_sr[2] ZN=n602
XU850 MUX2ND0BWP7T $PINS I0=n604 I1=n605 S=n517 ZN=N71
XU851 XNR2D1BWP7T $PINS A1=text_in_r[18] A2=w3[18] ZN=n605
XU852 XOR4D0BWP7T $PINS A1=sa13_sr[1] A2=n606 A3=sa03_sr[2] A4=n569 Z=n604
XU853 XNR2D1BWP7T $PINS A1=n607 A2=sa23_sr[1] ZN=n606
XU854 MUX2ND0BWP7T $PINS I0=n608 I1=n609 S=n517 ZN=N70
XU855 XNR2D1BWP7T $PINS A1=text_in_r[17] A2=w3[17] ZN=n609
XU856 XOR4D0BWP7T $PINS A1=n610 A2=sa03_sr[1] A3=n574 A4=n598 Z=n608
XU857 XNR3D0BWP7T $PINS A1=n611 A2=sa23_sr[0] A3=sa13_sr[0] ZN=n610
XU858 MUX2ND0BWP7T $PINS I0=n612 I1=n613 S=n517 ZN=N69
XU859 XNR2D1BWP7T $PINS A1=text_in_r[16] A2=w3[16] ZN=n613
XU860 XOR4D0BWP7T $PINS A1=n578 A2=n598 A3=sa03_sr[0] A4=w3[16] Z=n612
XU861 XNR2D1BWP7T $PINS A1=sa23_sr[7] A2=sa13_sr[7] ZN=n598
XU862 MUX2ND0BWP7T $PINS I0=n614 I1=n615 S=n517 ZN=N59
XU863 XNR2D1BWP7T $PINS A1=text_in_r[15] A2=w3[15] ZN=n615
XU864 XOR4D0BWP7T $PINS A1=n548 A2=n558 A3=sa33_sr[7] A4=n616 Z=n614
XU865 CKXOR2D0BWP7T $PINS A1=sa33_sr[6] A2=sa23_sr[6] Z=n548
XU866 MUX2ND0BWP7T $PINS I0=n617 I1=n618 S=n517 ZN=N58
XU867 XNR2D1BWP7T $PINS A1=text_in_r[14] A2=w3[14] ZN=n618
XU868 XOR4D0BWP7T $PINS A1=n543 A2=n554 A3=sa33_sr[6] A4=n619 Z=n617
XU869 CKXOR2D0BWP7T $PINS A1=sa33_sr[5] A2=sa23_sr[5] Z=n554
XU870 MUX2ND0BWP7T $PINS I0=n620 I1=n621 S=n517 ZN=N57
XU871 XNR2D1BWP7T $PINS A1=text_in_r[13] A2=w3[13] ZN=n621
XU872 XOR4D0BWP7T $PINS A1=n549 A2=n559 A3=sa33_sr[5] A4=w3[13] Z=n620
XU873 CKND0BWP7T $PINS I=n597 ZN=n559
XU874 CKXOR2D0BWP7T $PINS A1=sa33_sr[4] A2=sa23_sr[4] Z=n597
XU875 MUX2ND0BWP7T $PINS I0=n622 I1=n623 S=n517 ZN=N56
XU876 XNR2D1BWP7T $PINS A1=text_in_r[12] A2=w3[12] ZN=n623
XU877 XOR4D0BWP7T $PINS A1=n555 A2=n565 A3=n624 A4=n544 Z=n622
XU878 XNR2D1BWP7T $PINS A1=sa33_sr[4] A2=w3[12] ZN=n624
XU879 CKXOR2D0BWP7T $PINS A1=sa33_sr[3] A2=sa23_sr[3] Z=n565
XU880 MUX2ND0BWP7T $PINS I0=n625 I1=n626 S=n517 ZN=N55
XU881 XNR2D1BWP7T $PINS A1=text_in_r[11] A2=w3[11] ZN=n626
XU882 XOR4D0BWP7T $PINS A1=n561 A2=n569 A3=n627 A4=n544 Z=n625
XU883 XNR2D1BWP7T $PINS A1=sa33_sr[3] A2=w3[11] ZN=n627
XU884 XNR2D1BWP7T $PINS A1=sa33_sr[2] A2=sa23_sr[2] ZN=n569
XU885 CKND0BWP7T $PINS I=n628 ZN=n561
XU886 MUX2ND0BWP7T $PINS I0=n629 I1=n630 S=n517 ZN=N54
XU887 XNR2D1BWP7T $PINS A1=text_in_r[10] A2=w3[10] ZN=n630
XU888 XOR4D0BWP7T $PINS A1=n564 A2=n574 A3=sa33_sr[2] A4=n631 Z=n629
XU889 CKXOR2D0BWP7T $PINS A1=sa33_sr[1] A2=sa23_sr[1] Z=n574
XU890 MUX2ND0BWP7T $PINS I0=n632 I1=n633 S=n517 ZN=N53
XU891 XNR2D1BWP7T $PINS A1=text_in_r[9] A2=w3[9] ZN=n633
XU892 XOR4D0BWP7T $PINS A1=n570 A2=n578 A3=n634 A4=n544 Z=n632
XU893 XNR2D1BWP7T $PINS A1=sa33_sr[1] A2=w3[9] ZN=n634
XU894 CKXOR2D0BWP7T $PINS A1=sa33_sr[0] A2=sa23_sr[0] Z=n578
XU895 CKXOR2D0BWP7T $PINS A1=w3[0] A2=sa33_sr[0] Z=N521
XU896 CKXOR2D0BWP7T $PINS A1=w3[1] A2=sa33_sr[1] Z=N520
XU897 MUX2ND0BWP7T $PINS I0=n635 I1=n636 S=n517 ZN=N52
XU898 XNR2D1BWP7T $PINS A1=text_in_r[8] A2=w3[8] ZN=n636
XU899 XOR4D0BWP7T $PINS A1=n544 A2=n573 A3=sa33_sr[0] A4=n637 Z=n635
XU900 CKXOR2D0BWP7T $PINS A1=sa33_sr[7] A2=sa23_sr[7] Z=n544
XU901 CKXOR2D0BWP7T $PINS A1=w3[2] A2=sa33_sr[2] Z=N519
XU902 CKXOR2D0BWP7T $PINS A1=w3[3] A2=sa33_sr[3] Z=N518
XU903 CKXOR2D0BWP7T $PINS A1=w3[4] A2=sa33_sr[4] Z=N517
XU904 CKXOR2D0BWP7T $PINS A1=w3[5] A2=sa33_sr[5] Z=N516
XU905 CKXOR2D0BWP7T $PINS A1=w3[6] A2=sa33_sr[6] Z=N515
XU906 CKXOR2D0BWP7T $PINS A1=w3[7] A2=sa33_sr[7] Z=N514
XU907 CKXOR2D0BWP7T $PINS A1=w2[0] A2=sa32_sr[0] Z=N513
XU908 CKXOR2D0BWP7T $PINS A1=w2[1] A2=sa32_sr[1] Z=N512
XU909 CKXOR2D0BWP7T $PINS A1=w2[2] A2=sa32_sr[2] Z=N511
XU910 CKXOR2D0BWP7T $PINS A1=w2[3] A2=sa32_sr[3] Z=N510
XU911 CKXOR2D0BWP7T $PINS A1=w2[4] A2=sa32_sr[4] Z=N509
XU912 CKXOR2D0BWP7T $PINS A1=w2[5] A2=sa32_sr[5] Z=N508
XU913 CKXOR2D0BWP7T $PINS A1=w2[6] A2=sa32_sr[6] Z=N507
XU914 CKXOR2D0BWP7T $PINS A1=w2[7] A2=sa32_sr[7] Z=N506
XU915 CKXOR2D0BWP7T $PINS A1=w1[0] A2=sa31_sr[0] Z=N505
XU916 CKXOR2D0BWP7T $PINS A1=w1[1] A2=sa31_sr[1] Z=N504
XU917 CKXOR2D0BWP7T $PINS A1=w1[2] A2=sa31_sr[2] Z=N503
XU918 CKXOR2D0BWP7T $PINS A1=w1[3] A2=sa31_sr[3] Z=N502
XU919 CKXOR2D0BWP7T $PINS A1=w1[4] A2=sa31_sr[4] Z=N501
XU920 CKXOR2D0BWP7T $PINS A1=w1[5] A2=sa31_sr[5] Z=N500
XU921 CKXOR2D0BWP7T $PINS A1=w1[6] A2=sa31_sr[6] Z=N499
XU922 CKXOR2D0BWP7T $PINS A1=w1[7] A2=sa31_sr[7] Z=N498
XU923 CKXOR2D0BWP7T $PINS A1=w0[0] A2=sa30_sr[0] Z=N497
XU924 CKXOR2D0BWP7T $PINS A1=w0[1] A2=sa30_sr[1] Z=N496
XU925 CKXOR2D0BWP7T $PINS A1=w0[2] A2=sa30_sr[2] Z=N495
XU926 CKXOR2D0BWP7T $PINS A1=w0[3] A2=sa30_sr[3] Z=N494
XU927 CKXOR2D0BWP7T $PINS A1=w0[4] A2=sa30_sr[4] Z=N493
XU928 CKXOR2D0BWP7T $PINS A1=w0[5] A2=sa30_sr[5] Z=N492
XU929 CKXOR2D0BWP7T $PINS A1=w0[6] A2=sa30_sr[6] Z=N491
XU930 CKXOR2D0BWP7T $PINS A1=w0[7] A2=sa30_sr[7] Z=N490
XU931 XNR2D1BWP7T $PINS A1=n637 A2=sa23_sr[0] ZN=N489
XU932 CKND0BWP7T $PINS I=w3[8] ZN=n637
XU933 CKXOR2D0BWP7T $PINS A1=w3[9] A2=sa23_sr[1] Z=N488
XU934 XNR2D1BWP7T $PINS A1=n631 A2=sa23_sr[2] ZN=N487
XU935 CKND0BWP7T $PINS I=w3[10] ZN=n631
XU936 CKXOR2D0BWP7T $PINS A1=w3[11] A2=sa23_sr[3] Z=N486
XU937 CKXOR2D0BWP7T $PINS A1=w3[12] A2=sa23_sr[4] Z=N485
XU938 CKXOR2D0BWP7T $PINS A1=w3[13] A2=sa23_sr[5] Z=N484
XU939 XNR2D1BWP7T $PINS A1=n619 A2=sa23_sr[6] ZN=N483
XU940 CKND0BWP7T $PINS I=w3[14] ZN=n619
XU941 XNR2D1BWP7T $PINS A1=n616 A2=sa23_sr[7] ZN=N482
XU942 CKND0BWP7T $PINS I=w3[15] ZN=n616
XU943 CKXOR2D0BWP7T $PINS A1=w2[8] A2=sa22_sr[0] Z=N481
XU944 CKXOR2D0BWP7T $PINS A1=w2[9] A2=sa22_sr[1] Z=N480
XU945 CKXOR2D0BWP7T $PINS A1=w2[10] A2=sa22_sr[2] Z=N479
XU946 CKXOR2D0BWP7T $PINS A1=w2[11] A2=sa22_sr[3] Z=N478
XU947 CKXOR2D0BWP7T $PINS A1=w2[12] A2=sa22_sr[4] Z=N477
XU948 CKXOR2D0BWP7T $PINS A1=w2[13] A2=sa22_sr[5] Z=N476
XU949 CKXOR2D0BWP7T $PINS A1=w2[14] A2=sa22_sr[6] Z=N475
XU950 CKXOR2D0BWP7T $PINS A1=w2[15] A2=sa22_sr[7] Z=N474
XU951 CKXOR2D0BWP7T $PINS A1=w1[8] A2=sa21_sr[0] Z=N473
XU952 CKXOR2D0BWP7T $PINS A1=w1[9] A2=sa21_sr[1] Z=N472
XU953 CKXOR2D0BWP7T $PINS A1=w1[10] A2=sa21_sr[2] Z=N471
XU954 CKXOR2D0BWP7T $PINS A1=w1[11] A2=sa21_sr[3] Z=N470
XU955 CKXOR2D0BWP7T $PINS A1=w1[12] A2=sa21_sr[4] Z=N469
XU956 CKXOR2D0BWP7T $PINS A1=w1[13] A2=sa21_sr[5] Z=N468
XU957 CKXOR2D0BWP7T $PINS A1=w1[14] A2=sa21_sr[6] Z=N467
XU958 CKXOR2D0BWP7T $PINS A1=w1[15] A2=sa21_sr[7] Z=N466
XU959 CKXOR2D0BWP7T $PINS A1=w0[8] A2=sa20_sr[0] Z=N465
XU960 CKXOR2D0BWP7T $PINS A1=w0[9] A2=sa20_sr[1] Z=N464
XU961 CKXOR2D0BWP7T $PINS A1=w0[10] A2=sa20_sr[2] Z=N463
XU962 CKXOR2D0BWP7T $PINS A1=w0[11] A2=sa20_sr[3] Z=N462
XU963 CKXOR2D0BWP7T $PINS A1=w0[12] A2=sa20_sr[4] Z=N461
XU964 CKXOR2D0BWP7T $PINS A1=w0[13] A2=sa20_sr[5] Z=N460
XU965 CKXOR2D0BWP7T $PINS A1=w0[14] A2=sa20_sr[6] Z=N459
XU966 CKXOR2D0BWP7T $PINS A1=w0[15] A2=sa20_sr[7] Z=N458
XU967 CKXOR2D0BWP7T $PINS A1=w3[16] A2=sa13_sr[0] Z=N457
XU968 XNR2D1BWP7T $PINS A1=n611 A2=sa13_sr[1] ZN=N456
XU969 CKND0BWP7T $PINS I=w3[17] ZN=n611
XU970 XNR2D1BWP7T $PINS A1=n607 A2=sa13_sr[2] ZN=N455
XU971 CKND0BWP7T $PINS I=w3[18] ZN=n607
XU972 XNR2D1BWP7T $PINS A1=n603 A2=sa13_sr[3] ZN=N454
XU973 CKND0BWP7T $PINS I=w3[19] ZN=n603
XU974 XNR2D1BWP7T $PINS A1=n599 A2=sa13_sr[4] ZN=N453
XU975 CKND0BWP7T $PINS I=w3[20] ZN=n599
XU976 XNR2D1BWP7T $PINS A1=n593 A2=sa13_sr[5] ZN=N452
XU977 CKND0BWP7T $PINS I=w3[21] ZN=n593
XU978 XNR2D1BWP7T $PINS A1=n588 A2=sa13_sr[6] ZN=N451
XU979 CKND0BWP7T $PINS I=w3[22] ZN=n588
XU980 XNR2D1BWP7T $PINS A1=n583 A2=sa13_sr[7] ZN=N450
XU981 CKND0BWP7T $PINS I=w3[23] ZN=n583
XU982 CKXOR2D0BWP7T $PINS A1=w2[16] A2=sa12_sr[0] Z=N449
XU983 CKXOR2D0BWP7T $PINS A1=w2[17] A2=sa12_sr[1] Z=N448
XU984 CKXOR2D0BWP7T $PINS A1=w2[18] A2=sa12_sr[2] Z=N447
XU985 CKXOR2D0BWP7T $PINS A1=w2[19] A2=sa12_sr[3] Z=N446
XU986 CKXOR2D0BWP7T $PINS A1=w2[20] A2=sa12_sr[4] Z=N445
XU987 CKXOR2D0BWP7T $PINS A1=w2[21] A2=sa12_sr[5] Z=N444
XU988 CKXOR2D0BWP7T $PINS A1=w2[22] A2=sa12_sr[6] Z=N443
XU989 CKXOR2D0BWP7T $PINS A1=w2[23] A2=sa12_sr[7] Z=N442
XU990 CKXOR2D0BWP7T $PINS A1=w1[16] A2=sa11_sr[0] Z=N441
XU991 CKXOR2D0BWP7T $PINS A1=w1[17] A2=sa11_sr[1] Z=N440
XU992 CKXOR2D0BWP7T $PINS A1=w1[18] A2=sa11_sr[2] Z=N439
XU993 CKXOR2D0BWP7T $PINS A1=w1[19] A2=sa11_sr[3] Z=N438
XU994 CKXOR2D0BWP7T $PINS A1=w1[20] A2=sa11_sr[4] Z=N437
XU995 CKXOR2D0BWP7T $PINS A1=w1[21] A2=sa11_sr[5] Z=N436
XU996 CKXOR2D0BWP7T $PINS A1=w1[22] A2=sa11_sr[6] Z=N435
XU997 CKXOR2D0BWP7T $PINS A1=w1[23] A2=sa11_sr[7] Z=N434
XU998 CKXOR2D0BWP7T $PINS A1=w0[16] A2=sa10_sr[0] Z=N433
XU999 CKXOR2D0BWP7T $PINS A1=w0[17] A2=sa10_sr[1] Z=N432
XU1000 CKXOR2D0BWP7T $PINS A1=w0[18] A2=sa10_sr[2] Z=N431
XU1001 CKXOR2D0BWP7T $PINS A1=w0[19] A2=sa10_sr[3] Z=N430
XU1002 CKXOR2D0BWP7T $PINS A1=w0[20] A2=sa10_sr[4] Z=N429
XU1003 CKXOR2D0BWP7T $PINS A1=w0[21] A2=sa10_sr[5] Z=N428
XU1004 CKXOR2D0BWP7T $PINS A1=w0[22] A2=sa10_sr[6] Z=N427
XU1005 CKXOR2D0BWP7T $PINS A1=w0[23] A2=sa10_sr[7] Z=N426
XU1006 XNR2D1BWP7T $PINS A1=n579 A2=sa03_sr[0] ZN=N425
XU1007 CKND0BWP7T $PINS I=w3[24] ZN=n579
XU1008 XNR2D1BWP7T $PINS A1=w3[25] A2=n638 ZN=N424
XU1009 CKXOR2D0BWP7T $PINS A1=w3[26] A2=sa03_sr[2] Z=N423
XU1010 XNR2D1BWP7T $PINS A1=w3[27] A2=n639 ZN=N422
XU1011 CKND0BWP7T $PINS I=sa03_sr[3] ZN=n639
XU1012 XNR2D1BWP7T $PINS A1=w3[28] A2=n640 ZN=N421
XU1013 XNR2D1BWP7T $PINS A1=w3[29] A2=n592 ZN=N420
XU1014 MUX2ND0BWP7T $PINS I0=n641 I1=n642 S=n518 ZN=N42
XU1015 XNR2D1BWP7T $PINS A1=text_in_r[7] A2=w3[7] ZN=n642
XU1016 XOR4D0BWP7T $PINS A1=sa23_sr[7] A2=n643 A3=n587 A4=n558 Z=n641
XU1017 CKXOR2D0BWP7T $PINS A1=sa13_sr[7] A2=sa03_sr[7] Z=n558
XU1018 CKXOR2D0BWP7T $PINS A1=w3[7] A2=sa33_sr[6] Z=n643
XU1019 XNR2D1BWP7T $PINS A1=w3[30] A2=n587 ZN=N419
XU1020 CKND0BWP7T $PINS I=sa03_sr[6] ZN=n587
XU1021 XNR2D1BWP7T $PINS A1=n545 A2=sa03_sr[7] ZN=N418
XU1022 CKND0BWP7T $PINS I=w3[31] ZN=n545
XU1023 CKXOR2D0BWP7T $PINS A1=w2[24] A2=sa02_sr[0] Z=N417
XU1024 CKXOR2D0BWP7T $PINS A1=w2[25] A2=sa02_sr[1] Z=N416
XU1025 CKXOR2D0BWP7T $PINS A1=w2[26] A2=sa02_sr[2] Z=N415
XU1026 CKXOR2D0BWP7T $PINS A1=w2[27] A2=sa02_sr[3] Z=N414
XU1027 CKXOR2D0BWP7T $PINS A1=w2[28] A2=sa02_sr[4] Z=N413
XU1028 CKXOR2D0BWP7T $PINS A1=w2[29] A2=sa02_sr[5] Z=N412
XU1029 XNR2D1BWP7T $PINS A1=w2[30] A2=n644 ZN=N411
XU1030 CKXOR2D0BWP7T $PINS A1=w2[31] A2=sa02_sr[7] Z=N410
XU1031 MUX2ND0BWP7T $PINS I0=n645 I1=n646 S=n518 ZN=N41
XU1032 XNR2D1BWP7T $PINS A1=text_in_r[6] A2=w3[6] ZN=n646
XU1033 XOR4D0BWP7T $PINS A1=sa23_sr[6] A2=n647 A3=n592 A4=n543 Z=n645
XU1034 XNR2D1BWP7T $PINS A1=n550 A2=sa03_sr[6] ZN=n543
XU1035 CKND0BWP7T $PINS I=sa13_sr[6] ZN=n550
XU1036 CKXOR2D0BWP7T $PINS A1=w3[6] A2=sa33_sr[5] Z=n647
XU1037 CKXOR2D0BWP7T $PINS A1=w1[24] A2=sa01_sr[0] Z=N409
XU1038 CKXOR2D0BWP7T $PINS A1=w1[25] A2=sa01_sr[1] Z=N408
XU1039 CKXOR2D0BWP7T $PINS A1=w1[26] A2=sa01_sr[2] Z=N407
XU1040 CKXOR2D0BWP7T $PINS A1=w1[27] A2=sa01_sr[3] Z=N406
XU1041 CKXOR2D0BWP7T $PINS A1=w1[28] A2=sa01_sr[4] Z=N405
XU1042 CKXOR2D0BWP7T $PINS A1=w1[29] A2=sa01_sr[5] Z=N404
XU1043 XNR2D1BWP7T $PINS A1=w1[30] A2=n648 ZN=N403
XU1044 CKXOR2D0BWP7T $PINS A1=w1[31] A2=sa01_sr[7] Z=N402
XU1045 CKXOR2D0BWP7T $PINS A1=w0[24] A2=sa00_sr[0] Z=N401
XU1046 CKXOR2D0BWP7T $PINS A1=w0[25] A2=sa00_sr[1] Z=N400
XU1047 MUX2ND0BWP7T $PINS I0=n649 I1=n650 S=n518 ZN=N40
XU1048 XNR2D1BWP7T $PINS A1=text_in_r[5] A2=w3[5] ZN=n650
XU1049 XOR4D0BWP7T $PINS A1=sa23_sr[5] A2=n651 A3=n640 A4=n549 Z=n649
XU1050 XNR2D1BWP7T $PINS A1=sa13_sr[5] A2=n592 ZN=n549
XU1051 CKND0BWP7T $PINS I=sa03_sr[5] ZN=n592
XU1052 CKND0BWP7T $PINS I=sa03_sr[4] ZN=n640
XU1053 CKXOR2D0BWP7T $PINS A1=w3[5] A2=sa33_sr[4] Z=n651
XU1054 CKXOR2D0BWP7T $PINS A1=w0[26] A2=sa00_sr[2] Z=N399
XU1055 CKXOR2D0BWP7T $PINS A1=w0[27] A2=sa00_sr[3] Z=N398
XU1056 CKXOR2D0BWP7T $PINS A1=w0[28] A2=sa00_sr[4] Z=N397
XU1057 CKXOR2D0BWP7T $PINS A1=w0[29] A2=sa00_sr[5] Z=N396
XU1058 XNR2D1BWP7T $PINS A1=w0[30] A2=n652 ZN=N395
XU1059 CKXOR2D0BWP7T $PINS A1=w0[31] A2=sa00_sr[7] Z=N394
XU1060 MUX2ND0BWP7T $PINS I0=n653 I1=n654 S=n518 ZN=N39
XU1061 XNR2D1BWP7T $PINS A1=text_in_r[4] A2=w3[4] ZN=n654
XU1062 XOR4D0BWP7T $PINS A1=n655 A2=sa03_sr[3] A3=n555 A4=n656 Z=n653
XU1063 CKXOR2D0BWP7T $PINS A1=sa13_sr[4] A2=sa03_sr[4] Z=n555
XU1064 XOR3D0BWP7T $PINS A1=w3[4] A2=sa33_sr[3] A3=sa23_sr[4] Z=n655
XU1065 MUX2ND0BWP7T $PINS I0=n657 I1=n658 S=n518 ZN=N38
XU1066 XNR2D1BWP7T $PINS A1=text_in_r[3] A2=w3[3] ZN=n658
XU1067 XOR4D0BWP7T $PINS A1=n659 A2=sa03_sr[2] A3=n628 A4=n656 Z=n657
XU1068 CKXOR2D0BWP7T $PINS A1=sa13_sr[3] A2=sa03_sr[3] Z=n628
XU1069 XOR3D0BWP7T $PINS A1=w3[3] A2=sa33_sr[2] A3=sa23_sr[3] Z=n659
XU1070 MUX2ND0BWP7T $PINS I0=n660 I1=n661 S=n518 ZN=N37
XU1071 XNR2D1BWP7T $PINS A1=text_in_r[2] A2=w3[2] ZN=n661
XU1072 XOR4D0BWP7T $PINS A1=sa23_sr[2] A2=n662 A3=n638 A4=n564 Z=n660
XU1073 CKXOR2D0BWP7T $PINS A1=sa13_sr[2] A2=sa03_sr[2] Z=n564
XU1074 CKND0BWP7T $PINS I=sa03_sr[1] ZN=n638
XU1075 CKXOR2D0BWP7T $PINS A1=w3[2] A2=sa33_sr[1] Z=n662
XU1076 MUX2ND0BWP7T $PINS I0=n663 I1=n664 S=n518 ZN=N36
XU1077 XNR2D1BWP7T $PINS A1=text_in_r[1] A2=w3[1] ZN=n664
XU1078 XOR4D0BWP7T $PINS A1=n665 A2=sa03_sr[0] A3=n570 A4=n656 Z=n663
XU1079 CKXOR2D0BWP7T $PINS A1=sa13_sr[1] A2=sa03_sr[1] Z=n570
XU1080 XOR3D0BWP7T $PINS A1=w3[1] A2=sa33_sr[0] A3=sa23_sr[1] Z=n665
XU1081 MUX2ND0BWP7T $PINS I0=n666 I1=n667 S=n518 ZN=N35
XU1082 XNR2D1BWP7T $PINS A1=text_in_r[0] A2=w3[0] ZN=n667
XU1083 XOR4D0BWP7T $PINS A1=n573 A2=n656 A3=sa23_sr[0] A4=w3[0] Z=n666
XU1084 XNR2D1BWP7T $PINS A1=sa33_sr[7] A2=sa03_sr[7] ZN=n656
XU1085 CKXOR2D0BWP7T $PINS A1=sa13_sr[0] A2=sa03_sr[0] Z=n573
XU1086 MUX2ND0BWP7T $PINS I0=n668 I1=n669 S=n518 ZN=N297
XU1087 XNR2D1BWP7T $PINS A1=text_in_r[127] A2=w0[31] ZN=n669
XU1088 XOR4D0BWP7T $PINS A1=n670 A2=n671 A3=sa10_sr[7] A4=w0[31] Z=n668
XU1089 MUX2ND0BWP7T $PINS I0=n672 I1=n673 S=n518 ZN=N296
XU1090 XNR2D1BWP7T $PINS A1=text_in_r[126] A2=w0[30] ZN=n673
XU1091 XOR4D0BWP7T $PINS A1=n674 A2=n675 A3=sa10_sr[6] A4=w0[30] Z=n672
XU1092 MUX2ND0BWP7T $PINS I0=n676 I1=n677 S=n518 ZN=N295
XU1093 XNR2D1BWP7T $PINS A1=text_in_r[125] A2=w0[29] ZN=n677
XU1094 XOR4D0BWP7T $PINS A1=n678 A2=n679 A3=sa10_sr[5] A4=w0[29] Z=n676
XU1095 MUX2ND0BWP7T $PINS I0=n680 I1=n681 S=n518 ZN=N294
XU1096 XNR2D1BWP7T $PINS A1=text_in_r[124] A2=w0[28] ZN=n681
XU1097 XOR4D0BWP7T $PINS A1=n682 A2=n683 A3=n684 A4=n685 Z=n680
XU1098 XNR2D1BWP7T $PINS A1=sa10_sr[4] A2=w0[28] ZN=n684
XU1099 MUX2ND0BWP7T $PINS I0=n686 I1=n687 S=n519 ZN=N293
XU1100 XNR2D1BWP7T $PINS A1=text_in_r[123] A2=w0[27] ZN=n687
XU1101 XOR4D0BWP7T $PINS A1=n688 A2=n689 A3=n690 A4=n691 Z=n686
XU1102 XNR2D1BWP7T $PINS A1=sa10_sr[3] A2=w0[27] ZN=n690
XU1103 MUX2ND0BWP7T $PINS I0=n692 I1=n693 S=n519 ZN=N292
XU1104 XNR2D1BWP7T $PINS A1=text_in_r[122] A2=w0[26] ZN=n693
XU1105 XOR4D0BWP7T $PINS A1=n694 A2=n695 A3=sa10_sr[2] A4=w0[26] Z=n692
XU1106 MUX2ND0BWP7T $PINS I0=n696 I1=n697 S=n519 ZN=N291
XU1107 XNR2D1BWP7T $PINS A1=text_in_r[121] A2=w0[25] ZN=n697
XU1108 XOR4D0BWP7T $PINS A1=n698 A2=n699 A3=n700 A4=n682 Z=n696
XU1109 XNR2D1BWP7T $PINS A1=sa10_sr[1] A2=w0[25] ZN=n700
XU1110 MUX2ND0BWP7T $PINS I0=n701 I1=n702 S=n519 ZN=N290
XU1111 XNR2D1BWP7T $PINS A1=text_in_r[120] A2=w0[24] ZN=n702
XU1112 XOR4D0BWP7T $PINS A1=n691 A2=n703 A3=sa10_sr[0] A4=w0[24] Z=n701
XU1113 MUX2ND0BWP7T $PINS I0=n704 I1=n705 S=n519 ZN=N280
XU1114 XNR2D1BWP7T $PINS A1=text_in_r[119] A2=w0[23] ZN=n705
XU1115 XOR4D0BWP7T $PINS A1=sa10_sr[6] A2=n706 A3=sa00_sr[7] A4=n707 Z=n704
XU1116 CKXOR2D0BWP7T $PINS A1=w0[23] A2=sa20_sr[6] Z=n706
XU1117 MUX2ND0BWP7T $PINS I0=n708 I1=n709 S=n519 ZN=N279
XU1118 XNR2D1BWP7T $PINS A1=text_in_r[118] A2=w0[22] ZN=n709
XU1119 XOR4D0BWP7T $PINS A1=sa10_sr[5] A2=n710 A3=n652 A4=n675 Z=n708
XU1120 CKND0BWP7T $PINS I=sa00_sr[6] ZN=n652
XU1121 CKXOR2D0BWP7T $PINS A1=w0[22] A2=sa20_sr[5] Z=n710
XU1122 MUX2ND0BWP7T $PINS I0=n711 I1=n712 S=n519 ZN=N278
XU1123 XNR2D1BWP7T $PINS A1=text_in_r[117] A2=w0[21] ZN=n712
XU1124 XOR4D0BWP7T $PINS A1=sa10_sr[4] A2=n713 A3=sa00_sr[5] A4=n678 Z=n711
XU1125 CKXOR2D0BWP7T $PINS A1=w0[21] A2=sa20_sr[4] Z=n713
XU1126 MUX2ND0BWP7T $PINS I0=n714 I1=n715 S=n519 ZN=N277
XU1127 XNR2D1BWP7T $PINS A1=text_in_r[116] A2=w0[20] ZN=n715
XU1128 XOR4D0BWP7T $PINS A1=n716 A2=sa00_sr[4] A3=n683 A4=n717 Z=n714
XU1129 XOR3D0BWP7T $PINS A1=w0[20] A2=sa20_sr[3] A3=sa10_sr[3] Z=n716
XU1130 MUX2ND0BWP7T $PINS I0=n718 I1=n719 S=n519 ZN=N276
XU1131 XNR2D1BWP7T $PINS A1=text_in_r[115] A2=w0[19] ZN=n719
XU1132 XOR4D0BWP7T $PINS A1=n720 A2=sa00_sr[3] A3=n689 A4=n717 Z=n718
XU1133 XOR3D0BWP7T $PINS A1=w0[19] A2=sa20_sr[2] A3=sa10_sr[2] Z=n720
XU1134 MUX2ND0BWP7T $PINS I0=n721 I1=n722 S=n519 ZN=N275
XU1135 XNR2D1BWP7T $PINS A1=text_in_r[114] A2=w0[18] ZN=n722
XU1136 XOR4D0BWP7T $PINS A1=sa10_sr[1] A2=n723 A3=sa00_sr[2] A4=n694 Z=n721
XU1137 CKXOR2D0BWP7T $PINS A1=w0[18] A2=sa20_sr[1] Z=n723
XU1138 MUX2ND0BWP7T $PINS I0=n724 I1=n725 S=n519 ZN=N274
XU1139 XNR2D1BWP7T $PINS A1=text_in_r[113] A2=w0[17] ZN=n725
XU1140 XOR4D0BWP7T $PINS A1=n726 A2=sa00_sr[1] A3=n699 A4=n717 Z=n724
XU1141 XOR3D0BWP7T $PINS A1=w0[17] A2=sa20_sr[0] A3=sa10_sr[0] Z=n726
XU1142 MUX2ND0BWP7T $PINS I0=n727 I1=n728 S=n519 ZN=N273
XU1143 XNR2D1BWP7T $PINS A1=text_in_r[112] A2=w0[16] ZN=n728
XU1144 XOR4D0BWP7T $PINS A1=n703 A2=n717 A3=sa00_sr[0] A4=w0[16] Z=n727
XU1145 XNR2D1BWP7T $PINS A1=sa20_sr[7] A2=sa10_sr[7] ZN=n717
XU1146 MUX2ND0BWP7T $PINS I0=n729 I1=n730 S=n520 ZN=N263
XU1147 XNR2D1BWP7T $PINS A1=text_in_r[111] A2=w0[15] ZN=n730
XU1148 XOR4D0BWP7T $PINS A1=n675 A2=n691 A3=sa30_sr[7] A4=w0[15] Z=n729
XU1149 CKXOR2D0BWP7T $PINS A1=sa30_sr[6] A2=sa20_sr[6] Z=n675
XU1150 MUX2ND0BWP7T $PINS I0=n731 I1=n732 S=n520 ZN=N262
XU1151 XNR2D1BWP7T $PINS A1=text_in_r[110] A2=w0[14] ZN=n732
XU1152 XOR4D0BWP7T $PINS A1=n733 A2=n678 A3=sa30_sr[6] A4=w0[14] Z=n731
XU1153 XNR2D1BWP7T $PINS A1=sa30_sr[5] A2=sa20_sr[5] ZN=n678
XU1154 CKND0BWP7T $PINS I=n670 ZN=n733
XU1155 MUX2ND0BWP7T $PINS I0=n734 I1=n735 S=n520 ZN=N261
XU1156 XNR2D1BWP7T $PINS A1=text_in_r[109] A2=w0[13] ZN=n735
XU1157 XOR4D0BWP7T $PINS A1=n674 A2=n683 A3=sa30_sr[5] A4=w0[13] Z=n734
XU1158 CKXOR2D0BWP7T $PINS A1=sa30_sr[4] A2=sa20_sr[4] Z=n683
XU1159 MUX2ND0BWP7T $PINS I0=n736 I1=n737 S=n520 ZN=N260
XU1160 XNR2D1BWP7T $PINS A1=text_in_r[108] A2=w0[12] ZN=n737
XU1161 XOR4D0BWP7T $PINS A1=n679 A2=n689 A3=n738 A4=n671 Z=n736
XU1162 XNR2D1BWP7T $PINS A1=sa30_sr[4] A2=w0[12] ZN=n738
XU1163 CKXOR2D0BWP7T $PINS A1=sa30_sr[3] A2=sa20_sr[3] Z=n689
XU1164 MUX2ND0BWP7T $PINS I0=n739 I1=n740 S=n520 ZN=N259
XU1165 XNR2D1BWP7T $PINS A1=text_in_r[107] A2=w0[11] ZN=n740
XU1166 XOR4D0BWP7T $PINS A1=n685 A2=n694 A3=n741 A4=n707 Z=n739
XU1167 XNR2D1BWP7T $PINS A1=sa30_sr[3] A2=w0[11] ZN=n741
XU1168 XNR2D1BWP7T $PINS A1=sa30_sr[2] A2=sa20_sr[2] ZN=n694
XU1169 MUX2ND0BWP7T $PINS I0=n742 I1=n743 S=n520 ZN=N258
XU1170 XNR2D1BWP7T $PINS A1=text_in_r[106] A2=w0[10] ZN=n743
XU1171 XOR4D0BWP7T $PINS A1=n688 A2=n699 A3=sa30_sr[2] A4=w0[10] Z=n742
XU1172 CKXOR2D0BWP7T $PINS A1=sa30_sr[1] A2=sa20_sr[1] Z=n699
XU1173 MUX2ND0BWP7T $PINS I0=n744 I1=n745 S=n520 ZN=N257
XU1174 XNR2D1BWP7T $PINS A1=text_in_r[105] A2=w0[9] ZN=n745
XU1175 XOR4D0BWP7T $PINS A1=n695 A2=n703 A3=n746 A4=n671 Z=n744
XU1176 XNR2D1BWP7T $PINS A1=sa30_sr[1] A2=w0[9] ZN=n746
XU1177 CKXOR2D0BWP7T $PINS A1=sa30_sr[0] A2=sa20_sr[0] Z=n703
XU1178 MUX2ND0BWP7T $PINS I0=n747 I1=n748 S=n520 ZN=N256
XU1179 XNR2D1BWP7T $PINS A1=text_in_r[104] A2=w0[8] ZN=n748
XU1180 XOR4D0BWP7T $PINS A1=n707 A2=n698 A3=sa30_sr[0] A4=w0[8] Z=n747
XU1181 CKND0BWP7T $PINS I=n671 ZN=n707
XU1182 CKXOR2D0BWP7T $PINS A1=sa30_sr[7] A2=sa20_sr[7] Z=n671
XU1183 MUX2ND0BWP7T $PINS I0=n749 I1=n750 S=n520 ZN=N246
XU1184 XNR2D1BWP7T $PINS A1=text_in_r[103] A2=w0[7] ZN=n750
XU1185 XOR4D0BWP7T $PINS A1=sa20_sr[7] A2=n751 A3=sa00_sr[6] A4=n691 Z=n749
XU1186 CKND0BWP7T $PINS I=n682 ZN=n691
XU1187 CKXOR2D0BWP7T $PINS A1=sa10_sr[7] A2=sa00_sr[7] Z=n682
XU1188 CKXOR2D0BWP7T $PINS A1=w0[7] A2=sa30_sr[6] Z=n751
XU1189 MUX2ND0BWP7T $PINS I0=n752 I1=n753 S=n520 ZN=N245
XU1190 XNR2D1BWP7T $PINS A1=text_in_r[102] A2=w0[6] ZN=n753
XU1191 XOR4D0BWP7T $PINS A1=sa20_sr[6] A2=n754 A3=sa00_sr[5] A4=n670 Z=n752
XU1192 XNR2D1BWP7T $PINS A1=sa10_sr[6] A2=sa00_sr[6] ZN=n670
XU1193 CKXOR2D0BWP7T $PINS A1=w0[6] A2=sa30_sr[5] Z=n754
XU1194 MUX2ND0BWP7T $PINS I0=n755 I1=n756 S=n520 ZN=N244
XU1195 XNR2D1BWP7T $PINS A1=text_in_r[101] A2=w0[5] ZN=n756
XU1196 XOR4D0BWP7T $PINS A1=sa20_sr[5] A2=n757 A3=sa00_sr[4] A4=n674 Z=n755
XU1197 XNR2D1BWP7T $PINS A1=sa10_sr[5] A2=sa00_sr[5] ZN=n674
XU1198 CKXOR2D0BWP7T $PINS A1=w0[5] A2=sa30_sr[4] Z=n757
XU1199 MUX2ND0BWP7T $PINS I0=n758 I1=n759 S=n520 ZN=N243
XU1200 XNR2D1BWP7T $PINS A1=text_in_r[100] A2=w0[4] ZN=n759
XU1201 XOR4D0BWP7T $PINS A1=n760 A2=sa00_sr[3] A3=n679 A4=n761 Z=n758
XU1202 CKXOR2D0BWP7T $PINS A1=sa10_sr[4] A2=sa00_sr[4] Z=n679
XU1203 XOR3D0BWP7T $PINS A1=w0[4] A2=sa30_sr[3] A3=sa20_sr[4] Z=n760
XU1204 MUX2ND0BWP7T $PINS I0=n762 I1=n763 S=n521 ZN=N242
XU1205 XNR2D1BWP7T $PINS A1=text_in_r[99] A2=w0[3] ZN=n763
XU1206 XOR4D0BWP7T $PINS A1=n764 A2=sa00_sr[2] A3=n685 A4=n761 Z=n762
XU1207 CKXOR2D0BWP7T $PINS A1=sa10_sr[3] A2=sa00_sr[3] Z=n685
XU1208 XOR3D0BWP7T $PINS A1=w0[3] A2=sa30_sr[2] A3=sa20_sr[3] Z=n764
XU1209 MUX2ND0BWP7T $PINS I0=n765 I1=n766 S=n521 ZN=N241
XU1210 XNR2D1BWP7T $PINS A1=text_in_r[98] A2=w0[2] ZN=n766
XU1211 XOR4D0BWP7T $PINS A1=sa20_sr[2] A2=n767 A3=sa00_sr[1] A4=n688 Z=n765
XU1212 XNR2D1BWP7T $PINS A1=sa10_sr[2] A2=sa00_sr[2] ZN=n688
XU1213 CKXOR2D0BWP7T $PINS A1=w0[2] A2=sa30_sr[1] Z=n767
XU1214 MUX2ND0BWP7T $PINS I0=n768 I1=n769 S=n521 ZN=N240
XU1215 XNR2D1BWP7T $PINS A1=text_in_r[97] A2=w0[1] ZN=n769
XU1216 XOR4D0BWP7T $PINS A1=n770 A2=sa00_sr[0] A3=n695 A4=n761 Z=n768
XU1217 CKXOR2D0BWP7T $PINS A1=sa10_sr[1] A2=sa00_sr[1] Z=n695
XU1218 XOR3D0BWP7T $PINS A1=w0[1] A2=sa30_sr[0] A3=sa20_sr[1] Z=n770
XU1219 MUX2ND0BWP7T $PINS I0=n771 I1=n772 S=n521 ZN=N239
XU1220 XNR2D1BWP7T $PINS A1=text_in_r[96] A2=w0[0] ZN=n772
XU1221 XOR4D0BWP7T $PINS A1=n698 A2=n761 A3=sa20_sr[0] A4=w0[0] Z=n771
XU1222 XNR2D1BWP7T $PINS A1=sa30_sr[7] A2=sa00_sr[7] ZN=n761
XU1223 CKXOR2D0BWP7T $PINS A1=sa10_sr[0] A2=sa00_sr[0] Z=n698
XU1224 MUX2ND0BWP7T $PINS I0=n773 I1=n774 S=n521 ZN=N229
XU1225 XNR2D1BWP7T $PINS A1=text_in_r[95] A2=w1[31] ZN=n774
XU1226 XOR4D0BWP7T $PINS A1=n775 A2=n776 A3=sa11_sr[7] A4=w1[31] Z=n773
XU1227 MUX2ND0BWP7T $PINS I0=n777 I1=n778 S=n521 ZN=N228
XU1228 XNR2D1BWP7T $PINS A1=text_in_r[94] A2=w1[30] ZN=n778
XU1229 XOR4D0BWP7T $PINS A1=n779 A2=n780 A3=sa11_sr[6] A4=w1[30] Z=n777
XU1230 MUX2ND0BWP7T $PINS I0=n781 I1=n782 S=n521 ZN=N227
XU1231 XNR2D1BWP7T $PINS A1=text_in_r[93] A2=w1[29] ZN=n782
XU1232 XOR4D0BWP7T $PINS A1=n783 A2=n784 A3=sa11_sr[5] A4=w1[29] Z=n781
XU1233 MUX2ND0BWP7T $PINS I0=n785 I1=n786 S=n521 ZN=N226
XU1234 XNR2D1BWP7T $PINS A1=text_in_r[92] A2=w1[28] ZN=n786
XU1235 XOR4D0BWP7T $PINS A1=n787 A2=n788 A3=n789 A4=n790 Z=n785
XU1236 XNR2D1BWP7T $PINS A1=sa11_sr[4] A2=w1[28] ZN=n789
XU1237 MUX2ND0BWP7T $PINS I0=n791 I1=n792 S=n521 ZN=N225
XU1238 XNR2D1BWP7T $PINS A1=text_in_r[91] A2=w1[27] ZN=n792
XU1239 XOR4D0BWP7T $PINS A1=n793 A2=n794 A3=n795 A4=n796 Z=n791
XU1240 XNR2D1BWP7T $PINS A1=sa11_sr[3] A2=w1[27] ZN=n795
XU1241 MUX2ND0BWP7T $PINS I0=n797 I1=n798 S=n521 ZN=N224
XU1242 XNR2D1BWP7T $PINS A1=text_in_r[90] A2=w1[26] ZN=n798
XU1243 XOR4D0BWP7T $PINS A1=n799 A2=n800 A3=sa11_sr[2] A4=w1[26] Z=n797
XU1244 MUX2ND0BWP7T $PINS I0=n801 I1=n802 S=n521 ZN=N223
XU1245 XNR2D1BWP7T $PINS A1=text_in_r[89] A2=w1[25] ZN=n802
XU1246 XOR4D0BWP7T $PINS A1=n803 A2=n804 A3=n805 A4=n787 Z=n801
XU1247 XNR2D1BWP7T $PINS A1=sa11_sr[1] A2=w1[25] ZN=n805
XU1248 MUX2ND0BWP7T $PINS I0=n806 I1=n807 S=n521 ZN=N222
XU1249 XNR2D1BWP7T $PINS A1=text_in_r[88] A2=w1[24] ZN=n807
XU1250 XOR4D0BWP7T $PINS A1=n796 A2=n808 A3=sa11_sr[0] A4=w1[24] Z=n806
XU1251 INR4D0BWP7T $PINS A1=dcnt[0] B1=ld B2=dcnt[1] B3=n533 ZN=N22
XU1252 IND2D0BWP7T $PINS A1=dcnt[2] B1=n535 ZN=n533
XU1253 CKND0BWP7T $PINS I=dcnt[3] ZN=n535
XU1254 MUX2ND0BWP7T $PINS I0=n809 I1=n810 S=n522 ZN=N212
XU1255 XNR2D1BWP7T $PINS A1=text_in_r[87] A2=w1[23] ZN=n810
XU1256 XOR4D0BWP7T $PINS A1=sa11_sr[6] A2=n811 A3=sa01_sr[7] A4=n812 Z=n809
XU1257 CKXOR2D0BWP7T $PINS A1=w1[23] A2=sa21_sr[6] Z=n811
XU1258 MUX2ND0BWP7T $PINS I0=n813 I1=n814 S=n522 ZN=N211
XU1259 XNR2D1BWP7T $PINS A1=text_in_r[86] A2=w1[22] ZN=n814
XU1260 XOR4D0BWP7T $PINS A1=sa11_sr[5] A2=n815 A3=n648 A4=n780 Z=n813
XU1261 CKND0BWP7T $PINS I=sa01_sr[6] ZN=n648
XU1262 CKXOR2D0BWP7T $PINS A1=w1[22] A2=sa21_sr[5] Z=n815
XU1263 MUX2ND0BWP7T $PINS I0=n816 I1=n817 S=n522 ZN=N210
XU1264 XNR2D1BWP7T $PINS A1=text_in_r[85] A2=w1[21] ZN=n817
XU1265 XOR4D0BWP7T $PINS A1=sa11_sr[4] A2=n818 A3=sa01_sr[5] A4=n783 Z=n816
XU1266 CKXOR2D0BWP7T $PINS A1=w1[21] A2=sa21_sr[4] Z=n818
XU1267 MUX2ND0BWP7T $PINS I0=n819 I1=n820 S=n522 ZN=N209
XU1268 XNR2D1BWP7T $PINS A1=text_in_r[84] A2=w1[20] ZN=n820
XU1269 XOR4D0BWP7T $PINS A1=n821 A2=sa01_sr[4] A3=n788 A4=n822 Z=n819
XU1270 XOR3D0BWP7T $PINS A1=w1[20] A2=sa21_sr[3] A3=sa11_sr[3] Z=n821
XU1271 MUX2ND0BWP7T $PINS I0=n823 I1=n824 S=n522 ZN=N208
XU1272 XNR2D1BWP7T $PINS A1=text_in_r[83] A2=w1[19] ZN=n824
XU1273 XOR4D0BWP7T $PINS A1=n825 A2=sa01_sr[3] A3=n794 A4=n822 Z=n823
XU1274 XOR3D0BWP7T $PINS A1=w1[19] A2=sa21_sr[2] A3=sa11_sr[2] Z=n825
XU1275 MUX2ND0BWP7T $PINS I0=n826 I1=n827 S=n522 ZN=N207
XU1276 XNR2D1BWP7T $PINS A1=text_in_r[82] A2=w1[18] ZN=n827
XU1277 XOR4D0BWP7T $PINS A1=sa11_sr[1] A2=n828 A3=sa01_sr[2] A4=n799 Z=n826
XU1278 CKXOR2D0BWP7T $PINS A1=w1[18] A2=sa21_sr[1] Z=n828
XU1279 MUX2ND0BWP7T $PINS I0=n829 I1=n830 S=n522 ZN=N206
XU1280 XNR2D1BWP7T $PINS A1=text_in_r[81] A2=w1[17] ZN=n830
XU1281 XOR4D0BWP7T $PINS A1=n831 A2=sa01_sr[1] A3=n804 A4=n822 Z=n829
XU1282 XOR3D0BWP7T $PINS A1=w1[17] A2=sa21_sr[0] A3=sa11_sr[0] Z=n831
XU1283 MUX2ND0BWP7T $PINS I0=n832 I1=n833 S=n522 ZN=N205
XU1284 XNR2D1BWP7T $PINS A1=text_in_r[80] A2=w1[16] ZN=n833
XU1285 XOR4D0BWP7T $PINS A1=n808 A2=n822 A3=sa01_sr[0] A4=w1[16] Z=n832
XU1286 XNR2D1BWP7T $PINS A1=sa21_sr[7] A2=sa11_sr[7] ZN=n822
XU1287 MUX2ND0BWP7T $PINS I0=n834 I1=n835 S=n522 ZN=N195
XU1288 XNR2D1BWP7T $PINS A1=text_in_r[79] A2=w1[15] ZN=n835
XU1289 XOR4D0BWP7T $PINS A1=n780 A2=n796 A3=sa31_sr[7] A4=w1[15] Z=n834
XU1290 CKXOR2D0BWP7T $PINS A1=sa31_sr[6] A2=sa21_sr[6] Z=n780
XU1291 MUX2ND0BWP7T $PINS I0=n836 I1=n837 S=n522 ZN=N194
XU1292 XNR2D1BWP7T $PINS A1=text_in_r[78] A2=w1[14] ZN=n837
XU1293 XOR4D0BWP7T $PINS A1=n838 A2=n783 A3=sa31_sr[6] A4=w1[14] Z=n836
XU1294 XNR2D1BWP7T $PINS A1=sa31_sr[5] A2=sa21_sr[5] ZN=n783
XU1295 CKND0BWP7T $PINS I=n775 ZN=n838
XU1296 MUX2ND0BWP7T $PINS I0=n839 I1=n840 S=n522 ZN=N193
XU1297 XNR2D1BWP7T $PINS A1=text_in_r[77] A2=w1[13] ZN=n840
XU1298 XOR4D0BWP7T $PINS A1=n779 A2=n788 A3=sa31_sr[5] A4=w1[13] Z=n839
XU1299 CKXOR2D0BWP7T $PINS A1=sa31_sr[4] A2=sa21_sr[4] Z=n788
XU1300 MUX2ND0BWP7T $PINS I0=n841 I1=n842 S=n522 ZN=N192
XU1301 XNR2D1BWP7T $PINS A1=text_in_r[76] A2=w1[12] ZN=n842
XU1302 XOR4D0BWP7T $PINS A1=n784 A2=n794 A3=n843 A4=n776 Z=n841
XU1303 XNR2D1BWP7T $PINS A1=sa31_sr[4] A2=w1[12] ZN=n843
XU1304 CKXOR2D0BWP7T $PINS A1=sa31_sr[3] A2=sa21_sr[3] Z=n794
XU1305 MUX2ND0BWP7T $PINS I0=n844 I1=n845 S=n523 ZN=N191
XU1306 XNR2D1BWP7T $PINS A1=text_in_r[75] A2=w1[11] ZN=n845
XU1307 XOR4D0BWP7T $PINS A1=n790 A2=n799 A3=n846 A4=n812 Z=n844
XU1308 XNR2D1BWP7T $PINS A1=sa31_sr[3] A2=w1[11] ZN=n846
XU1309 XNR2D1BWP7T $PINS A1=sa31_sr[2] A2=sa21_sr[2] ZN=n799
XU1310 MUX2ND0BWP7T $PINS I0=n847 I1=n848 S=n523 ZN=N190
XU1311 XNR2D1BWP7T $PINS A1=text_in_r[74] A2=w1[10] ZN=n848
XU1312 XOR4D0BWP7T $PINS A1=n793 A2=n804 A3=sa31_sr[2] A4=w1[10] Z=n847
XU1313 CKXOR2D0BWP7T $PINS A1=sa31_sr[1] A2=sa21_sr[1] Z=n804
XU1314 MUX2ND0BWP7T $PINS I0=n849 I1=n850 S=n523 ZN=N189
XU1315 XNR2D1BWP7T $PINS A1=text_in_r[73] A2=w1[9] ZN=n850
XU1316 XOR4D0BWP7T $PINS A1=n800 A2=n808 A3=n851 A4=n776 Z=n849
XU1317 XNR2D1BWP7T $PINS A1=sa31_sr[1] A2=w1[9] ZN=n851
XU1318 CKXOR2D0BWP7T $PINS A1=sa31_sr[0] A2=sa21_sr[0] Z=n808
XU1319 MUX2ND0BWP7T $PINS I0=n852 I1=n853 S=n523 ZN=N188
XU1320 XNR2D1BWP7T $PINS A1=text_in_r[72] A2=w1[8] ZN=n853
XU1321 XOR4D0BWP7T $PINS A1=n812 A2=n803 A3=sa31_sr[0] A4=w1[8] Z=n852
XU1322 CKND0BWP7T $PINS I=n776 ZN=n812
XU1323 CKXOR2D0BWP7T $PINS A1=sa31_sr[7] A2=sa21_sr[7] Z=n776
XU1324 MUX2ND0BWP7T $PINS I0=n854 I1=n855 S=n523 ZN=N178
XU1325 XNR2D1BWP7T $PINS A1=text_in_r[71] A2=w1[7] ZN=n855
XU1326 XOR4D0BWP7T $PINS A1=sa21_sr[7] A2=n856 A3=sa01_sr[6] A4=n796 Z=n854
XU1327 CKND0BWP7T $PINS I=n787 ZN=n796
XU1328 CKXOR2D0BWP7T $PINS A1=sa11_sr[7] A2=sa01_sr[7] Z=n787
XU1329 CKXOR2D0BWP7T $PINS A1=w1[7] A2=sa31_sr[6] Z=n856
XU1330 MUX2ND0BWP7T $PINS I0=n857 I1=n858 S=n523 ZN=N177
XU1331 XNR2D1BWP7T $PINS A1=text_in_r[70] A2=w1[6] ZN=n858
XU1332 XOR4D0BWP7T $PINS A1=sa21_sr[6] A2=n859 A3=sa01_sr[5] A4=n775 Z=n857
XU1333 XNR2D1BWP7T $PINS A1=sa11_sr[6] A2=sa01_sr[6] ZN=n775
XU1334 CKXOR2D0BWP7T $PINS A1=w1[6] A2=sa31_sr[5] Z=n859
XU1335 MUX2ND0BWP7T $PINS I0=n860 I1=n861 S=n523 ZN=N176
XU1336 XNR2D1BWP7T $PINS A1=text_in_r[69] A2=w1[5] ZN=n861
XU1337 XOR4D0BWP7T $PINS A1=sa21_sr[5] A2=n862 A3=sa01_sr[4] A4=n779 Z=n860
XU1338 XNR2D1BWP7T $PINS A1=sa11_sr[5] A2=sa01_sr[5] ZN=n779
XU1339 CKXOR2D0BWP7T $PINS A1=w1[5] A2=sa31_sr[4] Z=n862
XU1340 MUX2ND0BWP7T $PINS I0=n863 I1=n864 S=n523 ZN=N175
XU1341 XNR2D1BWP7T $PINS A1=text_in_r[68] A2=w1[4] ZN=n864
XU1342 XOR4D0BWP7T $PINS A1=n865 A2=sa01_sr[3] A3=n784 A4=n866 Z=n863
XU1343 CKXOR2D0BWP7T $PINS A1=sa11_sr[4] A2=sa01_sr[4] Z=n784
XU1344 XOR3D0BWP7T $PINS A1=w1[4] A2=sa31_sr[3] A3=sa21_sr[4] Z=n865
XU1345 MUX2ND0BWP7T $PINS I0=n867 I1=n868 S=n523 ZN=N174
XU1346 XNR2D1BWP7T $PINS A1=text_in_r[67] A2=w1[3] ZN=n868
XU1347 XOR4D0BWP7T $PINS A1=n869 A2=sa01_sr[2] A3=n790 A4=n866 Z=n867
XU1348 CKXOR2D0BWP7T $PINS A1=sa11_sr[3] A2=sa01_sr[3] Z=n790
XU1349 XOR3D0BWP7T $PINS A1=w1[3] A2=sa31_sr[2] A3=sa21_sr[3] Z=n869
XU1350 MUX2ND0BWP7T $PINS I0=n870 I1=n871 S=n523 ZN=N173
XU1351 XNR2D1BWP7T $PINS A1=text_in_r[66] A2=w1[2] ZN=n871
XU1352 XOR4D0BWP7T $PINS A1=sa21_sr[2] A2=n872 A3=sa01_sr[1] A4=n793 Z=n870
XU1353 XNR2D1BWP7T $PINS A1=sa11_sr[2] A2=sa01_sr[2] ZN=n793
XU1354 CKXOR2D0BWP7T $PINS A1=w1[2] A2=sa31_sr[1] Z=n872
XU1355 MUX2ND0BWP7T $PINS I0=n873 I1=n874 S=n523 ZN=N172
XU1356 XNR2D1BWP7T $PINS A1=text_in_r[65] A2=w1[1] ZN=n874
XU1357 XOR4D0BWP7T $PINS A1=n875 A2=sa01_sr[0] A3=n800 A4=n866 Z=n873
XU1358 CKXOR2D0BWP7T $PINS A1=sa11_sr[1] A2=sa01_sr[1] Z=n800
XU1359 XOR3D0BWP7T $PINS A1=w1[1] A2=sa31_sr[0] A3=sa21_sr[1] Z=n875
XU1360 MUX2ND0BWP7T $PINS I0=n876 I1=n877 S=n523 ZN=N171
XU1361 XNR2D1BWP7T $PINS A1=text_in_r[64] A2=w1[0] ZN=n877
XU1362 XOR4D0BWP7T $PINS A1=n803 A2=n866 A3=sa21_sr[0] A4=w1[0] Z=n876
XU1363 XNR2D1BWP7T $PINS A1=sa31_sr[7] A2=sa01_sr[7] ZN=n866
XU1364 CKXOR2D0BWP7T $PINS A1=sa11_sr[0] A2=sa01_sr[0] Z=n803
XU1365 MUX2ND0BWP7T $PINS I0=n878 I1=n879 S=n524 ZN=N161
XU1366 XNR2D1BWP7T $PINS A1=text_in_r[63] A2=w2[31] ZN=n879
XU1367 XOR4D0BWP7T $PINS A1=n880 A2=n881 A3=sa12_sr[7] A4=w2[31] Z=n878
XU1368 MUX2ND0BWP7T $PINS I0=n882 I1=n883 S=n524 ZN=N160
XU1369 XNR2D1BWP7T $PINS A1=text_in_r[62] A2=w2[30] ZN=n883
XU1370 XOR4D0BWP7T $PINS A1=n884 A2=n885 A3=sa12_sr[6] A4=w2[30] Z=n882
XU1371 MUX2ND0BWP7T $PINS I0=n886 I1=n887 S=n524 ZN=N159
XU1372 XNR2D1BWP7T $PINS A1=text_in_r[61] A2=w2[29] ZN=n887
XU1373 XOR4D0BWP7T $PINS A1=n888 A2=n889 A3=sa12_sr[5] A4=w2[29] Z=n886
XU1374 MUX2ND0BWP7T $PINS I0=n890 I1=n891 S=n524 ZN=N158
XU1375 XNR2D1BWP7T $PINS A1=text_in_r[60] A2=w2[28] ZN=n891
XU1376 XOR4D0BWP7T $PINS A1=n892 A2=n893 A3=n894 A4=n895 Z=n890
XU1377 XNR2D1BWP7T $PINS A1=sa12_sr[4] A2=w2[28] ZN=n894
XU1378 MUX2ND0BWP7T $PINS I0=n896 I1=n897 S=n524 ZN=N157
XU1379 XNR2D1BWP7T $PINS A1=text_in_r[59] A2=w2[27] ZN=n897
XU1380 XOR4D0BWP7T $PINS A1=n898 A2=n899 A3=n900 A4=n901 Z=n896
XU1381 XNR2D1BWP7T $PINS A1=sa12_sr[3] A2=w2[27] ZN=n900
XU1382 MUX2ND0BWP7T $PINS I0=n902 I1=n903 S=n524 ZN=N156
XU1383 XNR2D1BWP7T $PINS A1=text_in_r[58] A2=w2[26] ZN=n903
XU1384 XOR4D0BWP7T $PINS A1=n904 A2=n905 A3=sa12_sr[2] A4=w2[26] Z=n902
XU1385 MUX2ND0BWP7T $PINS I0=n906 I1=n907 S=n524 ZN=N155
XU1386 XNR2D1BWP7T $PINS A1=text_in_r[57] A2=w2[25] ZN=n907
XU1387 XOR4D0BWP7T $PINS A1=n908 A2=n909 A3=n910 A4=n892 Z=n906
XU1388 XNR2D1BWP7T $PINS A1=sa12_sr[1] A2=w2[25] ZN=n910
XU1389 MUX2ND0BWP7T $PINS I0=n911 I1=n912 S=n524 ZN=N154
XU1390 XNR2D1BWP7T $PINS A1=text_in_r[56] A2=w2[24] ZN=n912
XU1391 XOR4D0BWP7T $PINS A1=n901 A2=n913 A3=sa12_sr[0] A4=w2[24] Z=n911
XU1392 MUX2ND0BWP7T $PINS I0=n914 I1=n915 S=n524 ZN=N144
XU1393 XNR2D1BWP7T $PINS A1=text_in_r[55] A2=w2[23] ZN=n915
XU1394 XOR4D0BWP7T $PINS A1=sa12_sr[6] A2=n916 A3=sa02_sr[7] A4=n917 Z=n914
XU1395 CKXOR2D0BWP7T $PINS A1=w2[23] A2=sa22_sr[6] Z=n916
XU1396 MUX2ND0BWP7T $PINS I0=n918 I1=n919 S=n524 ZN=N143
XU1397 XNR2D1BWP7T $PINS A1=text_in_r[54] A2=w2[22] ZN=n919
XU1398 XOR4D0BWP7T $PINS A1=sa12_sr[5] A2=n920 A3=n644 A4=n885 Z=n918
XU1399 CKND0BWP7T $PINS I=sa02_sr[6] ZN=n644
XU1400 CKXOR2D0BWP7T $PINS A1=w2[22] A2=sa22_sr[5] Z=n920
XU1401 MUX2ND0BWP7T $PINS I0=n921 I1=n922 S=n524 ZN=N142
XU1402 XNR2D1BWP7T $PINS A1=text_in_r[53] A2=w2[21] ZN=n922
XU1403 XOR4D0BWP7T $PINS A1=sa12_sr[4] A2=n923 A3=sa02_sr[5] A4=n888 Z=n921
XU1404 CKXOR2D0BWP7T $PINS A1=w2[21] A2=sa22_sr[4] Z=n923
XU1405 MUX2ND0BWP7T $PINS I0=n924 I1=n925 S=n524 ZN=N141
XU1406 XNR2D1BWP7T $PINS A1=text_in_r[52] A2=w2[20] ZN=n925
XU1407 XOR4D0BWP7T $PINS A1=n926 A2=sa02_sr[4] A3=n893 A4=n927 Z=n924
XU1408 XOR3D0BWP7T $PINS A1=w2[20] A2=sa22_sr[3] A3=sa12_sr[3] Z=n926
XU1409 MUX2ND0BWP7T $PINS I0=n928 I1=n929 S=n525 ZN=N140
XU1410 XNR2D1BWP7T $PINS A1=text_in_r[51] A2=w2[19] ZN=n929
XU1411 XOR4D0BWP7T $PINS A1=n930 A2=sa02_sr[3] A3=n899 A4=n927 Z=n928
XU1412 XOR3D0BWP7T $PINS A1=w2[19] A2=sa22_sr[2] A3=sa12_sr[2] Z=n930
XU1413 MUX2ND0BWP7T $PINS I0=n931 I1=n932 S=n525 ZN=N139
XU1414 XNR2D1BWP7T $PINS A1=text_in_r[50] A2=w2[18] ZN=n932
XU1415 XOR4D0BWP7T $PINS A1=sa12_sr[1] A2=n933 A3=sa02_sr[2] A4=n904 Z=n931
XU1416 CKXOR2D0BWP7T $PINS A1=w2[18] A2=sa22_sr[1] Z=n933
XU1417 MUX2ND0BWP7T $PINS I0=n934 I1=n935 S=n525 ZN=N138
XU1418 XNR2D1BWP7T $PINS A1=text_in_r[49] A2=w2[17] ZN=n935
XU1419 XOR4D0BWP7T $PINS A1=n936 A2=sa02_sr[1] A3=n909 A4=n927 Z=n934
XU1420 XOR3D0BWP7T $PINS A1=w2[17] A2=sa22_sr[0] A3=sa12_sr[0] Z=n936
XU1421 MUX2ND0BWP7T $PINS I0=n937 I1=n938 S=n525 ZN=N137
XU1422 XNR2D1BWP7T $PINS A1=text_in_r[48] A2=w2[16] ZN=n938
XU1423 XOR4D0BWP7T $PINS A1=n913 A2=n927 A3=sa02_sr[0] A4=w2[16] Z=n937
XU1424 XNR2D1BWP7T $PINS A1=sa22_sr[7] A2=sa12_sr[7] ZN=n927
XU1425 MUX2ND0BWP7T $PINS I0=n939 I1=n940 S=n525 ZN=N127
XU1426 XNR2D1BWP7T $PINS A1=text_in_r[47] A2=w2[15] ZN=n940
XU1427 XOR4D0BWP7T $PINS A1=n885 A2=n901 A3=sa32_sr[7] A4=w2[15] Z=n939
XU1428 CKXOR2D0BWP7T $PINS A1=sa32_sr[6] A2=sa22_sr[6] Z=n885
XU1429 MUX2ND0BWP7T $PINS I0=n941 I1=n942 S=n525 ZN=N126
XU1430 XNR2D1BWP7T $PINS A1=text_in_r[46] A2=w2[14] ZN=n942
XU1431 XOR4D0BWP7T $PINS A1=n943 A2=n888 A3=sa32_sr[6] A4=w2[14] Z=n941
XU1432 XNR2D1BWP7T $PINS A1=sa32_sr[5] A2=sa22_sr[5] ZN=n888
XU1433 CKND0BWP7T $PINS I=n880 ZN=n943
XU1434 MUX2ND0BWP7T $PINS I0=n944 I1=n945 S=n525 ZN=N125
XU1435 XNR2D1BWP7T $PINS A1=text_in_r[45] A2=w2[13] ZN=n945
XU1436 XOR4D0BWP7T $PINS A1=n884 A2=n893 A3=sa32_sr[5] A4=w2[13] Z=n944
XU1437 CKXOR2D0BWP7T $PINS A1=sa32_sr[4] A2=sa22_sr[4] Z=n893
XU1438 MUX2ND0BWP7T $PINS I0=n946 I1=n947 S=n525 ZN=N124
XU1439 XNR2D1BWP7T $PINS A1=text_in_r[44] A2=w2[12] ZN=n947
XU1440 XOR4D0BWP7T $PINS A1=n889 A2=n899 A3=n948 A4=n881 Z=n946
XU1441 XNR2D1BWP7T $PINS A1=sa32_sr[4] A2=w2[12] ZN=n948
XU1442 CKXOR2D0BWP7T $PINS A1=sa32_sr[3] A2=sa22_sr[3] Z=n899
XU1443 MUX2ND0BWP7T $PINS I0=n949 I1=n950 S=n525 ZN=N123
XU1444 XNR2D1BWP7T $PINS A1=text_in_r[43] A2=w2[11] ZN=n950
XU1445 XOR4D0BWP7T $PINS A1=n895 A2=n904 A3=n951 A4=n917 Z=n949
XU1446 XNR2D1BWP7T $PINS A1=sa32_sr[3] A2=w2[11] ZN=n951
XU1447 XNR2D1BWP7T $PINS A1=sa32_sr[2] A2=sa22_sr[2] ZN=n904
XU1448 MUX2ND0BWP7T $PINS I0=n952 I1=n953 S=n525 ZN=N122
XU1449 XNR2D1BWP7T $PINS A1=text_in_r[42] A2=w2[10] ZN=n953
XU1450 XOR4D0BWP7T $PINS A1=n898 A2=n909 A3=sa32_sr[2] A4=w2[10] Z=n952
XU1451 CKXOR2D0BWP7T $PINS A1=sa32_sr[1] A2=sa22_sr[1] Z=n909
XU1452 MUX2ND0BWP7T $PINS I0=n954 I1=n955 S=n525 ZN=N121
XU1453 XNR2D1BWP7T $PINS A1=text_in_r[41] A2=w2[9] ZN=n955
XU1454 XOR4D0BWP7T $PINS A1=n905 A2=n913 A3=n956 A4=n881 Z=n954
XU1455 XNR2D1BWP7T $PINS A1=sa32_sr[1] A2=w2[9] ZN=n956
XU1456 CKXOR2D0BWP7T $PINS A1=sa32_sr[0] A2=sa22_sr[0] Z=n913
XU1457 MUX2ND0BWP7T $PINS I0=n957 I1=n958 S=n525 ZN=N120
XU1458 XNR2D1BWP7T $PINS A1=text_in_r[40] A2=w2[8] ZN=n958
XU1459 XOR4D0BWP7T $PINS A1=n917 A2=n908 A3=sa32_sr[0] A4=w2[8] Z=n957
XU1460 CKND0BWP7T $PINS I=n881 ZN=n917
XU1461 CKXOR2D0BWP7T $PINS A1=sa32_sr[7] A2=sa22_sr[7] Z=n881
XU1462 MUX2ND0BWP7T $PINS I0=n959 I1=n960 S=n526 ZN=N110
XU1463 XNR2D1BWP7T $PINS A1=text_in_r[39] A2=w2[7] ZN=n960
XU1464 XOR4D0BWP7T $PINS A1=sa22_sr[7] A2=n961 A3=sa02_sr[6] A4=n901 Z=n959
XU1465 CKND0BWP7T $PINS I=n892 ZN=n901
XU1466 CKXOR2D0BWP7T $PINS A1=sa12_sr[7] A2=sa02_sr[7] Z=n892
XU1467 CKXOR2D0BWP7T $PINS A1=w2[7] A2=sa32_sr[6] Z=n961
XU1468 MUX2ND0BWP7T $PINS I0=n962 I1=n963 S=n526 ZN=N109
XU1469 XNR2D1BWP7T $PINS A1=text_in_r[38] A2=w2[6] ZN=n963
XU1470 XOR4D0BWP7T $PINS A1=sa22_sr[6] A2=n964 A3=sa02_sr[5] A4=n880 Z=n962
XU1471 XNR2D1BWP7T $PINS A1=sa12_sr[6] A2=sa02_sr[6] ZN=n880
XU1472 CKXOR2D0BWP7T $PINS A1=w2[6] A2=sa32_sr[5] Z=n964
XU1473 MUX2ND0BWP7T $PINS I0=n965 I1=n966 S=n526 ZN=N108
XU1474 XNR2D1BWP7T $PINS A1=text_in_r[37] A2=w2[5] ZN=n966
XU1475 XOR4D0BWP7T $PINS A1=sa22_sr[5] A2=n967 A3=sa02_sr[4] A4=n884 Z=n965
XU1476 XNR2D1BWP7T $PINS A1=sa12_sr[5] A2=sa02_sr[5] ZN=n884
XU1477 CKXOR2D0BWP7T $PINS A1=w2[5] A2=sa32_sr[4] Z=n967
XU1478 MUX2ND0BWP7T $PINS I0=n968 I1=n969 S=n526 ZN=N107
XU1479 XNR2D1BWP7T $PINS A1=text_in_r[36] A2=w2[4] ZN=n969
XU1480 XOR4D0BWP7T $PINS A1=n970 A2=sa02_sr[3] A3=n889 A4=n971 Z=n968
XU1481 CKXOR2D0BWP7T $PINS A1=sa12_sr[4] A2=sa02_sr[4] Z=n889
XU1482 XOR3D0BWP7T $PINS A1=w2[4] A2=sa32_sr[3] A3=sa22_sr[4] Z=n970
XU1483 MUX2ND0BWP7T $PINS I0=n972 I1=n973 S=n526 ZN=N106
XU1484 XNR2D1BWP7T $PINS A1=text_in_r[35] A2=w2[3] ZN=n973
XU1485 XOR4D0BWP7T $PINS A1=n974 A2=sa02_sr[2] A3=n895 A4=n971 Z=n972
XU1486 CKXOR2D0BWP7T $PINS A1=sa12_sr[3] A2=sa02_sr[3] Z=n895
XU1487 XOR3D0BWP7T $PINS A1=w2[3] A2=sa32_sr[2] A3=sa22_sr[3] Z=n974
XU1488 MUX2ND0BWP7T $PINS I0=n975 I1=n976 S=n526 ZN=N105
XU1489 XNR2D1BWP7T $PINS A1=text_in_r[34] A2=w2[2] ZN=n976
XU1490 XOR4D0BWP7T $PINS A1=sa22_sr[2] A2=n977 A3=sa02_sr[1] A4=n898 Z=n975
XU1491 XNR2D1BWP7T $PINS A1=sa12_sr[2] A2=sa02_sr[2] ZN=n898
XU1492 CKXOR2D0BWP7T $PINS A1=w2[2] A2=sa32_sr[1] Z=n977
XU1493 MUX2ND0BWP7T $PINS I0=n978 I1=n979 S=n526 ZN=N104
XU1494 XNR2D1BWP7T $PINS A1=text_in_r[33] A2=w2[1] ZN=n979
XU1495 XOR4D0BWP7T $PINS A1=n980 A2=sa02_sr[0] A3=n905 A4=n971 Z=n978
XU1496 CKXOR2D0BWP7T $PINS A1=sa12_sr[1] A2=sa02_sr[1] Z=n905
XU1497 XOR3D0BWP7T $PINS A1=w2[1] A2=sa32_sr[0] A3=sa22_sr[1] Z=n980
XU1498 MUX2ND0BWP7T $PINS I0=n981 I1=n982 S=n526 ZN=N103
XU1499 XNR2D1BWP7T $PINS A1=text_in_r[32] A2=w2[0] ZN=n982
XU1500 XOR4D0BWP7T $PINS A1=n908 A2=n971 A3=sa22_sr[0] A4=w2[0] Z=n981
XU1501 XNR2D1BWP7T $PINS A1=sa32_sr[7] A2=sa02_sr[7] ZN=n971
XU1502 CKXOR2D0BWP7T $PINS A1=sa12_sr[0] A2=sa02_sr[0] Z=n908
.ENDS
.GLOBAL VDD
.GLOBAL VSS
